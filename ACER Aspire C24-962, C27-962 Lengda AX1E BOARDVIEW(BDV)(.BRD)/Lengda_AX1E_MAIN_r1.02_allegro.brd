# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SMD-FPC-100P-5N-H
  rect 0.4x1.25 smd: 1(-1.5,0) 2(-0.5,0) 3(0.5,0) 4(1.5,0) 5(2.5,0)
  rect 2x2.5 smd: E1(-3.69,-2.83) E2(4.69,-2.83)
SMD-HDMI-CN-50P-19BN
  oval 0.28x1.9 smd: 1(4.21,2.6) 2(3.71,2.6) 3(3.21,2.6) 4(2.71,2.6) 5(2.21,2.6) 6(1.71,2.6) 7(1.21,2.6) 8(0.71,2.6) 9(0.21,2.6) 10(-0.29,2.6) 11(-0.79,2.6) 12(-1.29,2.6) 13(-1.79,2.6) 14(-2.29,2.6) 15(-2.79,2.6) 16(-3.29,2.6) 17(-3.79,2.6) 18(-4.29,2.6) 19(-4.79,2.6)
  round 1.9 hole 1.3: E1(-7.25,0) E2(7.25,0) E3(0,-3.3)
SMD-M2PCIE-50X750P-75AN
  round 0.254 hole 1.092 unplated: (-10,-1.499)
  round 0.254 hole 1.6 unplated: (10,-1.499)
  rect 0.305x1.575 smd: 1(-9.25,3.763) 2(-9,-3.763) 3(-8.75,3.763) 4(-8.5,-3.763) 5(-8.25,3.763) 6(-8,-3.763) 7(-7.75,3.763) 8(-7.5,-3.763) 9(-7.25,3.763) 10(-7,-3.763) 11(-6.75,3.763) 12(-6.5,-3.763) 13(-6.25,3.763) 14(-6,-3.763) 15(-5.75,3.763) 16(-5.5,-3.763) 17(-5.25,3.763) 18(-5,-3.763) 19(-4.75,3.763) 20(-4.5,-3.763) 21(-4.25,3.763) 22(-4,-3.763) 23(-3.75,3.763) 24(-3.5,-3.763) 25(-3.25,3.763) 26(-3,-3.763) 27(-2.75,3.763) 28(-2.5,-3.763) 29(-2.25,3.763) 30(-2,-3.763) 31(-1.75,3.763) 32(-1.5,-3.763) 33(-1.25,3.763) 34(-1,-3.763) 35(-0.75,3.763) 36(-0.5,-3.763) 37(-0.25,3.763) 38(0,-3.763) 39(0.25,3.763) 40(0.5,-3.763) 41(0.75,3.763) 42(1,-3.763) 43(1.25,3.763) 44(1.5,-3.763) 45(1.75,3.763) 46(2,-3.763) 47(2.25,3.763) 48(2.5,-3.763) 49(2.75,3.763) 50(3,-3.763) 51(3.25,3.763) 52(3.5,-3.763) 53(3.75,3.763) 54(4,-3.763) 55(4.25,3.763) 56(4.5,-3.763) 57(4.75,3.763) 58(5,-3.763) 59(5.25,3.763) 60(5.5,-3.763) 61(5.75,3.763) 62(6,-3.763) 63(6.25,3.763) 64(6.5,-3.763) 65(6.75,3.763) 66(7,-3.763) 67(7.25,3.763) 68(7.5,-3.763) 69(7.75,3.763) 70(8,-3.763) 71(8.25,3.763) 72(8.5,-3.763) 73(8.75,3.763) 74(9,-3.763) 75(9.25,3.763)
  rect 1.219x2.769 smd: E1(-10.39,3.001) E2(10.39,3.001)
SMD-M2PCIE-50X750P-75BN
  round 0.254 hole 1.092 unplated: (-10,-1.499)
  round 0.254 hole 1.6 unplated: (10,-1.499)
  rect 0.305x1.575 smd: 1(-9.25,3.763) 2(-9,-3.763) 3(-8.75,3.763) 4(-8.5,-3.763) 5(-8.25,3.763) 6(-8,-3.763) 7(-7.75,3.763) 8(-7.5,-3.763) 9(-7.25,3.763) 10(-7,-3.763) 11(-6.75,3.763) 12(-6.5,-3.763) 13(-6.25,3.763) 14(-6,-3.763) 15(-5.75,3.763) 16(-5.5,-3.763) 17(-5.25,3.763) 18(-5,-3.763) 19(-4.75,3.763) 20(-4.5,-3.763) 21(-4.25,3.763) 22(-4,-3.763) 23(-3.75,3.763) 24(-3.5,-3.763) 25(-3.25,3.763) 26(-3,-3.763) 27(-2.75,3.763) 28(-2.5,-3.763) 29(-2.25,3.763) 30(-2,-3.763) 31(-1.75,3.763) 32(-1.5,-3.763) 33(-1.25,3.763) 34(-1,-3.763) 35(-0.75,3.763) 36(-0.5,-3.763) 37(-0.25,3.763) 38(0,-3.763) 39(0.25,3.763) 40(0.5,-3.763) 41(0.75,3.763) 42(1,-3.763) 43(1.25,3.763) 44(1.5,-3.763) 45(1.75,3.763) 46(2,-3.763) 47(2.25,3.763) 48(2.5,-3.763) 49(2.75,3.763) 50(3,-3.763) 51(3.25,3.763) 52(3.5,-3.763) 53(3.75,3.763) 54(4,-3.763) 55(4.25,3.763) 56(4.5,-3.763) 57(4.75,3.763) 58(5,-3.763) 67(7.25,3.763) 68(7.5,-3.763) 69(7.75,3.763) 70(8,-3.763) 71(8.25,3.763) 72(8.5,-3.763) 73(8.75,3.763) 74(9,-3.763) 75(9.25,3.763)
  rect 1.219x2.769 smd: E1(-10.39,3.001) E2(10.39,3.001)
SMY126X63
  rect 1.803x0.991 smd: 1(0,1.245) 2(0,-1.245)
SOD0806N
  rect 0.4x0.35 smd: N(-0.45,0) P(0.45,0)
SOD0808N
  rect 0.8x0.8 smd: 1(-1.175,0) 2(1.175,0)
SOD1713N
  rect 0.8x0.6 smd: N(1.25,0) P(-1.25,0)
SOD2514N
  rect 1.2x0.5 smd: N(-1.15,0) P(1.15,0)
SOD2818N
  rect 2.2x1.4 smd: N(1,0)
  rect 0.9x1.4 smd: P(-1.65,0)
SOD5225N
  rect 2x2 smd: N(-2.095,0) P(2.095,0)
SOD5336N
  rect 2.5x2.3 smd: N(2.15,0) P(-2.15,0)
SOIC127P540-8N
  rect 1.9x0.6 smd: 1(0,0) 2(0,-1.27) 3(0,-2.54) 4(0,-3.81) 5(6.756,-3.81) 6(6.756,-2.54) 7(6.756,-1.27) 8(6.756,0)
SOIC127P600-8N
  rect 1.9x0.6 smd: 1(-2.55,1.905) 2(-2.55,0.635) 3(-2.55,-0.635) 4(-2.55,-1.905) 5(2.55,-1.905) 6(2.55,-0.635) 7(2.55,0.635) 8(2.55,1.905)
SOIC127P605X520-8N
  rect 0.7x0.5 smd: 1(-2.825,1.905) 2(-2.825,0.635) 3(-2.825,-0.635) 4(-2.825,-1.905) 5(2.825,-1.905) 6(2.825,-0.635) 7(2.825,0.635)
  custom 1.12x1.12 smd: 8(0.7,0)
SOIC127P800-8N
  rect 1.8x0.6 smd: 1(-3.6,1.905) 2(-3.6,0.635) 3(-3.6,-0.635) 4(-3.6,-1.905) 5(3.6,-1.905) 6(3.6,-0.635) 7(3.6,0.635) 8(3.6,1.905)
SON50P200X200-8N
  oval 0.6x0.25 smd: 1(-1,0.749) 2(-1,0.249) 3(-1,-0.251) 4(-1,-0.751) 5(1,-0.751) 6(1,-0.251) 7(1,0.249) 8(1,0.749)
  rect 0.9x1.6 smd: E1(0,0)
SON65P330X330-8N
  rect 0.65x0.35 smd: 1(-1.65,0.975) 2(-1.65,0.325) 3(-1.65,-0.325) 4(-1.65,-0.975) 5(1.65,-0.975) 6(1.65,-0.325) 7(1.65,0.325)
  custom 0.65x0.65 smd: 8(0,0)
SOP99P996-24N
  rect 1.5x0.72 smd: 1(-4.5,5.484) 2(-4.5,4.494) 3(-4.5,3.504) 4(-4.5,2.514) 5(-4.5,1.524) 6(-4.5,0.534) 7(-4.5,-0.456) 8(-4.5,-1.446) 9(-4.5,-2.436) 10(-4.5,-3.426) 11(-4.5,-4.416) 12(-4.5,-5.406) 13(4.5,-5.406) 14(4.5,-4.416) 15(4.5,-3.426) 16(4.5,-2.436) 17(4.5,-1.446) 18(4.5,-0.456) 19(4.5,0.534) 20(4.5,1.524) 21(4.5,2.514) 22(4.5,3.504) 23(4.5,4.494) 24(4.5,5.484)
SOP127P600-9N
  rect 1.9x0.6 smd: 1(-2.55,1.905) 2(-2.55,0.635) 3(-2.55,-0.635) 4(-2.55,-1.905) 5(2.55,-1.905) 6(2.55,-0.635) 7(2.55,0.635) 8(2.55,1.905)
  rect 2.6x3 smd: E1(0,0)
SOT65P190-5N
  oval 1.1x0.35 smd: 1(-0.95,0.65) 2(-0.95,0) 3(-0.95,-0.65) 4(0.95,-0.65) 5(0.95,0.65)
SOT65P210-3N
  rect 1.2x0.45 smd: 1(-0.9,0.65) 2(-0.9,-0.65) 3(0.9,0)
SOT65P210-5N
  rect 1.1x0.4 smd: 1(-0.95,0.65) 2(-0.95,0) 3(-0.95,-0.65) 4(0.95,-0.65) 5(0.95,0.65)
SOT95P240-3N
  rect 1.4x0.6 smd: 1(-1,0.95) 2(-1,-0.95) 3(1,0)
SOT95P280-3N
  rect 1.35x0.6 smd: 1(-1.25,0.95) 2(-1.25,-0.95) 3(1.25,0)
SOT95P280-5N
  rect 1.3x0.6 smd: 1(-1.25,0.95) 2(-1.25,0) 3(-1.25,-0.95) 4(1.25,-0.95) 5(1.25,0.95)
SOT229P990-3N
  rect 1x2.2 smd: 1(-2.29,-3.35) 2(2.29,-3.35)
  rect 5.5x5.3 smd: 3(0,3.15)
SOT_23_M
  rect 1.016x1.016 smd: 1(-0.95,-0.991) 2(0.95,-0.991)
  rect 0.889x1.27 smd: 3(0,1.016)
TDFN50P300X300-10N
  oval 0.65x0.25 smd: 1(-1.325,1) 2(-1.325,0.5) 3(-1.325,0) 4(-1.325,-0.5) 5(-1.325,-1) 6(1.325,-1) 7(1.325,-0.5) 8(1.325,0) 9(1.325,0.5) 10(1.325,1)
  rect 1.5x2.5 smd: E1(0,0)
TEST60
  round 0.6 smd: 1(0,0)
TH-DCIN-540P-3N
  round 1.3 hole 1.3 unplated: (-4.25,4.5) (4.25,-4.5)
  oval 2x3.5 hole 0.9x2.5: B(-4,1)
  oval 3.5x2 hole 2.5x0.9: C(-2,-4.4) D(2.6,-2)
TH-EARPHONE-330X400P-5N
  round 1.1 hole 1.1 unplated: (0,-2.55)
  oval 2.1x1.2 hole 1.5x0.6: 2(0,2.55)
  oval 1.2x2.1 hole 0.6x1.5: 3(-4,1.65) 4(4,1.65) 5(-2.5,-1.65) 6(2.5,-1.65)
TH-RJ45-127P-8N
  round 3.2 hole 3.2 unplated: (-5.715,1.1) (5.715,1.1)
  round 1.05 hole 0.7: 1(-4.445,7.45) 2(-3.175,7.45) 3(-1.905,7.45) 4(-0.635,7.45) 5(0.635,7.45) 6(1.905,7.45) 7(3.175,7.45) 8(4.445,7.45)
  round 2.6 hole 1.6: E1(-7.875,4.99) E2(7.875,4.99)
TH-SATA-127P-22AN-R-KX
  round 1.1 hole 1.1 unplated: (-20.21,2.5) (22.24,2.5)
  oval 2x3.4 hole 1x2.4: E1(-23.785,3.3) E2(25.815,3.3)
  round 1 hole 0.7: P1(1.905,1.9) P2(0.635,1.9) P3(-0.635,1.9) P4(-1.905,1.9) P5(-3.175,1.9) P6(-4.445,1.9) P7(-5.715,1.9) P8(-6.985,1.9) P9(-8.255,1.9) P10(-9.525,1.9) P11(-10.795,1.9) P12(-12.065,1.9) P13(-13.335,1.9) P14(-14.605,1.9) P15(-15.875,1.9) S1(15.875,1.9) S2(14.605,1.9) S3(13.335,1.9) S4(12.065,1.9) S5(10.795,1.9) S6(9.525,1.9) S7(8.255,1.9)
TH-SW-420P-2N
  round 1 hole 1 unplated: (-1.15,0) (1.15,0)
  rect 1.2x1.5 smd: 1(-2.1,1) 2(2.1,1)
  rect 1.3x1.2 smd: E1(-3.525,-0.8) E2(3.525,-0.8)
TH-USB-200X150P-9KN
  round 1.2 hole 0.8: 1(-3.5,-1.05) 2(-1,-1.05) 3(1,-1.05) 4(3.5,-1.05) 5(4,0.45) 6(2,0.45) 7(0,0.45) 8(-2,0.45) 9(-4,0.45)
  oval 2.4x3.1 hole 1.7x2.1: E1(-6.57,-0.95) E2(6.57,-0.95)
TH-USB-250PX200P-4BN
  round 1.55 hole 0.95: 1(-3.5,0.81) 2(-1,0.81) 3(1,0.81) 4(3.5,0.81)
  oval 1.2x2.1 hole 0.6x1.5: E1(-6.4,0.21) E2(6.4,0.21)
THR-CPR50-630X1100N
  round 1.5 hole 0.7: 1(-1.25,0) 2(1.25,0)
TP_C25
  round 0.635 smd: 1(0,0)
TPC12
  round 0.305 smd: 1(0,0)
TSSOP65P640-16AN
  rect 1.6x0.35 smd: 1(-3,2.275) 2(-3,1.625) 3(-3,0.975) 4(-3,0.325) 5(-3,-0.325) 6(-3,-0.975) 7(-3,-1.625) 8(-3,-2.275) 9(3,-2.275) 10(3,-1.625) 11(3,-0.975) 12(3,-0.325) 13(3,0.325) 14(3,0.975) 15(3,1.625) 16(3,2.275)
  rect 3x2.8 smd: E1(0,0)
unnamed
  round 2 hole 2 unplated: (0,0)

## Nets
+V1.05A_EN: R199.1 R378.1
+V1.05A_EN_R: C350.2 R194.2 R378.2 R858.2 U24.6(EN)
+V1.8A_PCH: R53.2 R96.1 R442.2 U1.DD35(VCCPRIM_1P8_1) U1.DF15(VCCPRIM_1P8_2) U1.DF17(VCCPRIM_1P8_3) U1.DF18(VCCPRIM_1P8_4) U1.DF20(VCCPRIM_1P8_5) U1.DF34(VCCPRIM_1P8_9) U1.DG17(VCCPRIM_1P8_6) U1.DG18(VCCPRIM_1P8_7) U1.DG20(VCCPRIM_1P8_8)
+V1.8U_2.5U_MEM: C49.1 C87.1 C137.2 C138.2 C211.1 C212.1 C213.1 C879.1 C880.1 C881.2 C882.2 CN11.257(VPP1) CN11.259(VPP2) CN19.257(VPP1) CN19.259(VPP2) R187.2 U52.3(VOUT1) U52.4(VOUT2)
+V1P05A: C2.2 C4.2 C6129.1 C6130.2 FB39.1 FB40.1 FB41.1(FB1) FB43.1(FB1) R800.2 R867.1 U15.1(VIN1) U15.2(VIN2) U21.1(VIN1) U21.2(VIN2)
+V1P05A_E: C50.1 C104.1 C158.1 C159.1 C160.1 C336.1 C338.1 C343.1 C344.1 FB39.2 L7.2 R6.2 R211.2
+V1P05S_VCCST: C5.2 C354.1 C355.1 C6136.1 C6137.1 FB43.2(FB2) R32.2 R65.1 R98.1 R124.1 R129.1 R305.2 R306.1 R357.1 R438.1 U1.CB1(VCCST) U13.5(VCC) U15.7(VOUT2) U15.8(VOUT1)
+V1P05S_VCCST_PWRGD: Q48.3(D) R836.2 U9.69(ADC3/GPI3)
+V1P05S_VCCSTG: C262.2 C356.1 C357.1 FB41.2(FB2) R357.2 U1.BY1(VCCSTG) U21.7(VOUT2) U21.8(VOUT1)
+V1P8A: C209.1 C210.1 C272.2 C273.2 C398.2 L18.2 PR29.2 PR37.2 R53.1 R177.2 R181.2 R191.2 R313.1 R317.1 R374.2 R443.2 R466.2 R832.1 R834.1 U1.BG9(VCC1P8A_1) U1.BJ9(VCC1P8A_2) U1.BM9(VCC1P8A_3) U1.BW1(VCC1P8A_4) U1.BW2(VCC1P8A_5) U55.1(VIN1) U55.2(VIN2)
+V1P8S: C400.2 C468.2 C469.1 FB17.2 FB25.2 FB31.2 R46.2 R404.2 R664.1 R665.1 U25.40(AVDD2) U55.7(VOUT2) U55.8(VOUT1)
+V3.3_LAN: C51.1 C414.1 C415.1 C416.1 C417.1 C418.1 C419.1 R218.1 R351.2 R813.2 R821.1 U4.1(VOUT) U18.5(VCC) U30.11(AVDD33) U30.32(AVDD33_1)
+V3.3_WIFI: C55.1 C56.2 C57.2 C58.1 C80.2 C90.2 C147.1 CN22.2(3.3V_2) CN22.4(3.3V_4) CN22.72(3.3V_72) CN22.74(3.3V_74) FB1.1 R240.2 R248.2 R420.2 U10.5(VCC) U14.1(VOUT)
+V3.3A_KBC: C68.2 C69.2 C341.1 FB13.2 R13.2 R48.1 R84.1 R86.1 R88.1 R105.1 R238.2 R322.2 R325.1 R349.1 R352.1 R359.1 R360.1 R560.2 R561.2 R835.1 R836.1 R1388.2 R1393.1 U9.26(VSTBY) U9.50(VSTBY1) U9.92(VSTBY2) U9.112(VSTBY0) U9.114(VSTBY4) U9.121(VSTBY5) U9.127(VSTBY6) U36.8(VCC) U36_S.8(VCC)
+V3.3A_PCH: C358.2 R52.2 R66.1 U1.DB34(VCCSPI) U1.DC33(VCCPRIM_3P3_1) U1.DF23(VCCPRIM_3P3_2) U1.DG26(VCCPRIM_3P3_3) U1.DG28(VCCPRIM_3P3_4)
+V3.3AVCC: C70.1 FB13.1 U9.74(AVCC)
+V3.3S: C139.2 C141.2 C218.2 C219.1 C282.2 C340.2 C375.1 C432.2 C449.2 C491.1 C493.1 C494.2 C495.2 C507.2 C536.2 C545.2 C883.2 C884.2 C6058.1 C6158.1 CN11.255(VDDSPD) CN14.24(+3.3V_AUX) CN14.52(+3.3V_2) CN19.255(VDDSPD) D26.2(X2) FB3.1 FB6.2 FB8.2 FB12.2 FB24.2 FB28.2 PR17.2 PR68.1 Q1.1(G) Q2.1(G) Q14.1(G) Q19.1(G) Q27.1(G) Q42.1(G) Q56.1(S1) Q56.2(S2) Q56.3(S3) R47.2 R59.1 R72.2 R78.2 R182.1 R183.2 R192.2 R236.2 R241.2 R247.2 R252.1 R292.2 R323.1 R369.2 R370.2 R380.1 R385.1 R386.1 R446.1 R557.1 R574.2 R634.2 R635.2 R649.1 R655.2 R734.2 R735.2 R740.2 R797.2 R828.1 R833.1 U5.5(VCC) U23.5(VCC) U32.5(VCC) U33.5(VCC) U34.5(VCC) U35.5(VCC)
+V3.3S_AUDIO: FB28.1 FB30.2 R399.1 R408.1 R409.1 R410.1
+V3.3S_DMIC: CN2.8 CN2.9 CN2.10 FB16.1
+V3.3S_DVDD: C482.1 C483.2 FB30.1 FB31.1 R396.1 R400.1 R401.1 R507.1 U25.1(DVDD)
+V3.3S_MSATA: C88.2 C263.2 C264.2 CN10.2(3.3V_2) CN10.4(3.3V_4) CN10.12(3.3V_12) CN10.14(3.3V_14) CN10.16(3.3V_16) CN10.18(3.3V_18) CN10.70(3.3V_70) CN10.72(3.3V_72) CN10.74(3.3V_74) FB6.1 FB8.1 R210.2 R338.2 U40.5(VCC)
+V3P3_BIOS_SPI: C877.2 C878.2 R476.2 R721.1 R722.1 R723.1 U49.8(VCC) U49_1.8(VCC)
+V3P3_DSW: C32.1 C33.1 C226.1 CP5.1 D1.P FB4.2 FB5.2 L3.2 Q74.5(D1) Q74.6(D2) Q74.7(D3) Q74.8(D4) R13.1 R22.1 R28.1 R31.1 R34.1 R37.1 R38.2 R40.2 R51.1 R69.1 R97.1 R792.1
+V3P3_DSW_EN: C331.2 R899.2 U20.11(BYP/LDO)
+V3P3A: C52.1 C53.1 C143.1 C144.2 C217.1 C394.2 C395.1 FB1.2 FB4.1 FB5.1 FB9.1 FB16.2 FB18.2 LED2.1(P) Q56.5(D1) Q56.6(D2) Q56.7(D3) Q56.8(D4) Q74.1(S1) Q74.2(S2) Q74.3(S3) R3.1 R8.1 R9.2 R10.2 R12.1 R16.1 R30.1 R49.2 R52.1 R57.2 R58.2 R70.2 R92.1 R93.1 R107.2 R115.1 R116.1 R139.1 R154.1 R156.1 R160.2 R175.2 R176.1 R179.2 R194.1 R195.2 R197.2 R205.1 R234.1 R245.2 R310.2 R311.1 R312.1 R316.2 R346.1 R347.1 R373.1 R412.1 R476.1 R609.1 R610.1 R632.1 R633.1 R636.1 R637.1 R644.2 R647.1 R648.1 R650.2 R653.2 R654.2 R821.2 R831.2 R860.1 R862.1 R866.2 R873.2 R876.2 R904.2 R905.2 R906.2 R907.2 R927.1 R928.1 R933.2 R934.2 U4.5(VIN) U14.5(VIN) U54.5(VCC) U56.5(VCC) U57.5(VCC)
+V3P3A_RTC: C136.2 C308.2 D1.N D3.N R25.2 R27.2 R50.1 R71.2
+V5_AVDD: C279.2 C339.1 C463.2 C464.2 FB27.2 FB38.2 U25.26(AVDD1)
+V5_PVDD: C476.2 C477.2 C480.2 C481.2 FB26.1 U25.41(PVDD1) U25.46(PVDD2)
+V5_VCCIN_AUX_VCC: C21.2 R321.2 U6.15(PVCC) U6.16(VCC)
+V5A: C16.1 C18.1 C25.1 C27.1 C75.2 C83.2 C84.2 C114.2 C128.2 C145.2 C195.2 C223.1 C295.2 C322.2 C385.2 C399.2 C411.1 C412.2 C520.2 C798.2 CP4.1 D5.1(X1) F2.1 F3.1 F5.1 F6.1 FB38.1 L2.2 PC42.1 PR3.2 PR12.2 PR78.1 PR92.2 PR98.1 Q68.5(D1) Q68.6(D2) Q68.7(D3) Q68.8(D4) R184.2 R206.2 R309.1 R321.1 R449.1 R478.1 R490.1 R793.2 R795.2 R918.1 U2.12(VDD) U7.10(FB/VOUT) U11.5(VIN) U15.4(VBIAS) U16.4(VBIAS) U21.4(VBIAS) U22.5(VIN) U27.5(VIN) U29.5(VIN) U39.4(VBIAS) U52.6(VCNTL) U55.4(VBIAS)
+V5S: C6.2 C220.2 C222.1 C231.2 C337.1 C450.1 C455.1 C459.2 C521.1 C522.1 C634.2 C635.1 C6056.1 C6159.1 CN14.8(UIM_PWR1) D4.2(X2) D7.P D16.2(X2) F1.1 FB14.2 FB15.1 FB21.2 FB26.2 FB27.1 Q68.1(S1) Q68.2(S2) Q68.3(S3) R138.1 R140.1 R165.1 R258.1 R393.2 R558.1 R573.2 R578.1 R624.2 R752.1 R796.2 R1400.1 U38.3(VIN) U41.5(VIN)
+V5S_CAM: C390.1 C393.1 C524.2 C525.1 CN12.1 F1.2 R931.2 U41.1(VOUT)
+V5S_HDD: C444.1 C445.2 C446.1 CN9.P8 CN9.P9 FB14.1 FB21.1 R506.1
+V5S_HDMI: C230.2 CN3.18 U38.2(VOUT)
+V15A: C29.1 D6.2(X2) R196.1 R203.1 R791.1 R815.1
+VCC1.05_OUT_FET: C6128.1 C6131.1 FB40.2 U1.BY2(VCC1P05_1) U1.CB2(VCC1P05_2) U1.CC1(VCC1P05_3)
+VCC1.05_OUT_PCH: R212.1 U1.DG31(VCCPRIM_1P05_1)
+VCC1.05_OUT_PCH_R: R212.2 U1.DF29(VCCPRIM_1P05_3) U1.DF31(VCCPRIM_1P05_4) U1.DG29(VCCPRIM_1P05_2)
+VCC1.05_OUT_SFR: C6138.2 C6139.2 R856.1 U1.CD1(VCC1P05_OUT_PLL)
+VCC_EFUSEPRG: C6126.1 R843.2 U1.A33(RSVD_2) U1.B33(RSVD_3)
+VCCA_CLKLDO_1P8: C200.1 R442.1 U1.DW15(VCCA_CLKLDO_1P8)
+VCCDPHY_1P24: C192.2 U1.DW32(VCCDPHY_1P24)
+VCCDSW_1P05: C198.2 U1.DD34(VCCDSW_1P05)
+VCCFPGM: C274.1 R903.2 U1.AA35(RSVD_75) U1.AB34(VCCSTG_OUT_7) U1.R35(VCCSTG_OUT_3) U1.T34(VCCSTG_OUT_5) U1.U35(VCCSTG_OUT_6) U1.V34(VCCSTG_OUT_4) U1.W35(RSVD_74) U1.Y34(RSVD_76)
+VCCHDA: R46.1 R47.1 R260.2 R627.1 R628.1
+VCCIN: C63.1 C122.1 C123.1 C124.1 C125.1 C126.1 C135.1 C183.1 C184.1 C291.1 C313.1 C314.1 C315.1 C316.2 C361.2 C362.2 C363.2 C364.2 C365.2 C366.2 C377.2 C379.1 C380.2 C383.2 C384.2 C388.2 C389.1 C391.1 C392.1 C397.1 C402.1 C403.1 C404.1 C405.1 C406.1 C439.1 C513.1 C516.1 C519.1 C695.1 C696.1 C697.1 C698.1 C699.1 C700.1 C701.1 C702.1 C703.1 C704.1 C705.1 C706.1 C707.1 C708.1 C709.1 C710.1 C711.1 C712.1 C713.1 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C722.2 C723.2 C724.2 C725.2 C726.2 C727.2 C6112.1 C6113.1 C6114.1 C6115.1 C6116.1 C6117.1 C6118.1 C6119.1 C6120.1 CP18.1 CP19.1 CP20.1 LPM1.2 LPM2.2 LPM3.2 NS2.1(N1) PC8.1 PC21.1 PC39.1 PC58.1 PC59.1 PC61.1 PR2.2 PR31.1 PR54.1 PR55.1 R781.2 R784.2 R785.2 R801.2 U1.A19(VCCIN_1) U1.A21(VCCIN_17) U1.A23(VCCIN_28) U1.A24(VCCIN_39) U1.A27(VCCIN_50) U1.A29(VCCIN_61) U1.AA12(VCCIN_72) U1.AB1(VCCIN_83) U1.AB13(VCCIN_94) U1.AC12(VCCIN_2) U1.B19(VCCIN_8) U1.B23(VCCIN_9) U1.B27(VCCIN_10) U1.B29(VCCIN_11) U1.BN10(VCCIN_12) U1.BP9(VCCIN_14) U1.BP11(VCCIN_13) U1.BR10(VCCIN_15) U1.BT9(VCCIN_18) U1.BT11(VCCIN_16) U1.BU10(VCCIN_19) U1.BV9(VCCIN_21) U1.BV36(VCCIN_20) U1.BW9(VCCIN_24) U1.BW10(VCCIN_22) U1.BW36(VCCIN_23) U1.BY10(VCCIN_25) U1.C19(VCCIN_26) U1.C23(VCCIN_27) U1.C27(VCCIN_29) U1.C29(VCCIN_30) U1.CA9(VCCIN_32) U1.CA36(VCCIN_31) U1.CB10(VCCIN_33) U1.CC9(VCCIN_36) U1.CC11(VCCIN_34) U1.CC36(VCCIN_35) U1.CD10(VCCIN_37) U1.CE11(VCCIN_38) U1.CE34(VCCIN_40) U1.CE35(VCCIN_41) U1.CF10(VCCIN_42) U1.CF33(VCCIN_43) U1.CG11(VCCIN_44) U1.CG34(VCCIN_45) U1.CG35(VCCIN_46) U1.CH10(VCCIN_47) U1.CJ11(VCCIN_49) U1.CJ34(VCCIN_51) U1.CJ35(VCCIN_52) U1.CK10(VCCIN_53) U1.CL34(VCCIN_55) U1.CL35(VCCIN_56) U1.CN34(VCCIN_57) U1.CN35(VCCIN_58) U1.CP33(VCCIN_59) U1.CR34(VCCIN_60) U1.CR35(VCCIN_62) U1.CT33(VCCIN_63) U1.CT34(VCCIN_64) U1.CT35(VCCIN_65) U1.CU33(VCCIN_66) U1.D19(VCCIN_67) U1.D21(VCCIN_68) U1.D23(VCCIN_69) U1.D24(VCCIN_70) U1.D27(VCCIN_71) U1.D29(VCCIN_73) U1.F19(VCCIN_74) U1.F21(VCCIN_75) U1.F23(VCCIN_76) U1.F24(VCCIN_77) U1.F27(VCCIN_78) U1.F29(VCCIN_79) U1.G1(VCCIN_80) U1.G19(VCCIN_81) U1.G23(VCCIN_82) U1.G27(VCCIN_84) U1.G29(VCCIN_85) U1.H19(VCCIN_86) U1.H23(VCCIN_87) U1.H27(VCCIN_88) U1.H29(VCCIN_89) U1.J18(VCCIN_90) U1.J20(VCCIN_91) U1.J22(VCCIN_92) U1.J23(VCCIN_93) U1.J26(VCCIN_95) U1.J28(VCCIN_96) U1.J30(VCCIN_48) U1.J32(VCCIN_54) U1.K17(VCCIN_97) U1.K19(VCCIN_98) U1.K21(VCCIN_99) U1.K23(VCCIN_100) U1.K24(VCCIN_101) U1.K27(VCCIN_102) U1.K29(VCCIN_6) U1.K31(VCCIN_7) U1.M1(VCCIN_103) U1.U1(VCCIN_104) U1.V13(VCCIN_3) U1.W12(VCCIN_4) U1.Y13(VCCIN_5)
+VCCIO_OUT: R106.1 R146.1 R147.1 R149.1 R169.1 R250.1 R283.1 R336.1 R343.1 U1.AD7(VCCIO_OUT)
+VCCLDOSTD_OUT_0P85: U1.DW37(VCCLDOSTD_0P85) UC1.1
+VCCPDSW_3P3: R51.2 U1.DE31(VCCDSW_3P3)
+VCCPGPPR_3P3_1P8: R66.2 R96.2 U1.DF26(VCCPGPPR)
+VCCPLL: C270.1 C271.1 C6132.1 R855.2 R856.2 U1.CD2(VCCPLL)
+VCCPRTC_3P3: C359.2 C360.2 R50.2 R54.2 U1.DG33(VCCRTC)
+VCCSFR_OC: C216.2 C348.1 C353.1 FB42.2(FB2) U1.CG38(VCCPLL_OC_1) U1.CG41(VCCPLL_OC_2) U1.CG42(VCCPLL_OC_3) U1.CG49(VCCPLL_OC_4) U16.7(VOUT2) U16.8(VOUT1)
+VCCSTG_OUT_FUSE: C22.1 R903.1 U1.F33(VCCSTG_OUT_1) U1.G33(VCCSTG_OUT_2)
+VCCSTG_OUT_LGC: R122.1 R131.2 R132.2 R133.2 R135.2 R137.2 R141.2 R889.2 U1.E5(VCCSTG_OUT_LGC)
+VDDQ_MEM: C127.2 C132.1 C134.1 C140.1 C161.2 C162.2 C163.2 C164.2 C165.2 C166.2 C167.2 C168.2 C169.2 C170.2 C171.2 C172.2 C173.2 C174.2 C175.2 C176.2 C193.1 C194.1 C199.2 C275.1 C276.1 C280.1 C283.1 C284.1 C285.1 C286.1 C287.1 C288.1 C289.1 C290.1 C296.1 C297.1 C298.1 C299.2 C300.2 C301.2 C302.2 C303.2 C304.2 C305.1 C306.1 C307.1 C309.1 C310.1 C311.1 C312.1 C317.1 C318.1 C319.1 C320.1 C321.1 C325.1 C326.1 C327.1 C328.1 C329.1 C334.1 C347.1 C888.2 C889.2 C890.2 C891.2 C892.2 C893.2 C894.2 C895.2 C896.2 C897.2 C898.2 C899.2 C900.2 C901.2 C902.2 C903.2 CN11.12(DM0*/DBI0*) CN11.33(DM1*/DBI1*) CN11.54(DM2*/DBI2*) CN11.75(DM3*/DBI3*) CN11.96(DM8*/DBI8*) CN11.111(VDD1) CN11.112(VDD2) CN11.117(VDD3) CN11.118(VDD4) CN11.123(VDD5) CN11.124(VDD6) CN11.129(VDD7) CN11.130(VDD8) CN11.135(VDD9) CN11.136(VDD10) CN11.141(VDD11) CN11.142(VDD12) CN11.147(VDD13) CN11.148(VDD14) CN11.153(VDD15) CN11.154(VDD16) CN11.159(VDD17) CN11.160(VDD18) CN11.163(VDD19) CN11.178(DM4*/DBI4*) CN11.199(DM5*/DBI5*) CN11.220(DM6*/DBI6*) CN11.241(DM7*/DBI7*) CN19.12(DM0*/DBI0*) CN19.33(DM1*/DBI1*) CN19.54(DM2*/DBI2*) CN19.75(DM3*/DBI3*) CN19.96(DM8*/DBI8*) CN19.111(VDD1) CN19.112(VDD2) CN19.117(VDD3) CN19.118(VDD4) CN19.123(VDD5) CN19.124(VDD6) CN19.129(VDD7) CN19.130(VDD8) CN19.135(VDD9) CN19.136(VDD10) CN19.141(VDD11) CN19.142(VDD12) CN19.147(VDD13) CN19.148(VDD14) CN19.153(VDD15) CN19.154(VDD16) CN19.159(VDD17) CN19.160(VDD18) CN19.163(VDD19) CN19.178(DM4*/DBI4*) CN19.199(DM5*/DBI5*) CN19.220(DM6*/DBI6*) CN19.241(DM7*/DBI7*) CP2.1 CP3.1 FB42.1(FB1) L6.2 R42.2 R123.2 R127.2 R229.1 R291.1 R293.1 R294.1 R295.1 R296.1 R297.1 R298.1 R299.1 R300.2 R302.2 R303.2 R730.1 R733.1 R739.1 R741.1 R742.1 R743.1 R744.1 R745.1 R746.1 R747.2 R748.1 R750.2 R751.2 R794.2 R855.1 U1.AA37(VDDQ_1) U1.AA49(VDDQ_12) U1.AB36(VDDQ_23) U1.AC35(VDDQ_34) U1.AC37(VDDQ_43) U1.AD35(VDDQ_44) U1.AD36(VDDQ_45) U1.AE36(VDDQ_46) U1.AF49(VDDQ_47) U1.AG36(VDDQ_2) U1.AJ36(VDDQ_3) U1.AL36(VDDQ_4) U1.AL49(VDDQ_5) U1.AN36(VDDQ_6) U1.AP37(VDDQ_7) U1.AR36(VDDQ_8) U1.AR37(VDDQ_9) U1.AT36(VDDQ_10) U1.AT49(VDDQ_11) U1.AV36(VDDQ_13) U1.AW37(VDDQ_14) U1.AY36(VDDQ_15) U1.BA37(VDDQ_16) U1.BA49(VDDQ_17) U1.BB36(VDDQ_18) U1.BD36(VDDQ_19) U1.BE37(VDDQ_20) U1.BF36(VDDQ_21) U1.BF37(VDDQ_22) U1.BF49(VDDQ_24) U1.BG36(VDDQ_25) U1.BJ36(VDDQ_26) U1.BL37(VDDQ_27) U1.BM49(VDDQ_28) U1.BN37(VDDQ_29) U1.BP38(VDDQ_30) U1.BP39(VDDQ_31) U1.BR37(VDDQ_32) U1.BT38(VDDQ_33) U1.BU37(VDDQ_35) U1.BU49(VDDQ_36) U1.CA39(VDDQ_37) U1.CB49(VDDQ_38) U1.L38(VDDQ_39) U1.L49(VDDQ_40) U1.N36(VDDQ_41) U1.T49(VDDQ_42) U2.5(VDDQ) U2.19(VLDOIN) U16.1(VIN1) U16.2(VIN2) U50.5(VCC)
+VDDQ_VTT: C86.2 C177.2 C178.2 C179.2 C180.2 C181.2 C904.2 C905.2 C906.2 C907.2 C908.2 CN11.258(VTT) CN19.258(VTT) R799.2 U2.2(VTTSNS) U2.20(VTT)
AGND: ACN1.2 ACN1.E1 ACN1.E2 C456.1 C458.2 C463.1 C464.1 C468.1 C469.2 C472.1 C475.1 C499.1 C500.1 C501.1 C502.1 C6125.2 FB22.2 J7.2 J7.5 J8.2 J8.5 R389.1 U25.25(AVSS1) U25.38(AVSS2)
AVDD2_AUDIO: C484.1 C485.2 FB24.1 FB25.1 U25.9(DVDD-IO)
AVDD33_REG: C420.2 C421.1 R218.2 U30.23(VDDREG)
GND: C1.2 C2.1 C4.1 C5.1 C6.1 C7.2 C8.1 C9.2 C10.1 C11.2 C13.2 C14.2 C15.2 C16.2 C18.2 C19.2 C20.2 C21.1 C22.2 C25.2 C26.1 C27.2 C28.2 C29.2 C30.1 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.1 C57.1 C58.2 C59.2 C63.2 C68.1 C69.1 C70.2 C75.1 C76.1 C80.1 C82.1 C83.1 C84.1 C86.1 C87.2 C88.1 C90.1 C104.2 C114.1 C118.2 C122.2 C123.2 C124.2 C125.2 C126.2 C127.1 C128.1 C129.2 C131.1 C132.2 C134.2 C135.2 C136.1 C137.1 C138.1 C139.1 C140.2 C141.1 C142.1 C143.2 C144.1 C145.1 C146.1 C147.2 C156.1 C157.1 C158.2 C159.2 C160.2 C161.1 C162.1 C163.1 C164.1 C165.1 C166.1 C167.1 C168.1 C169.1 C170.1 C171.1 C172.1 C173.1 C174.1 C175.1 C176.1 C177.1 C178.1 C179.1 C180.1 C181.1 C183.2 C184.2 C185.2 C188.2 C189.2 C190.2 C191.1 C192.1 C193.2 C194.2 C195.1 C198.1 C199.1 C200.2 C201.2 C202.2 C205.2 C207.2 C209.2 C210.2 C211.2 C212.2 C213.2 C214.2 C215.1 C216.1 C217.2 C218.1 C219.2 C220.1 C222.2 C223.2 C224.1 C225.1 C226.2 C229.2 C230.1 C231.1 C232.1 C235.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.2 C245.2 C246.2 C247.2 C248.2 C249.2 C250.2 C251.2 C252.1 C253.1 C254.1 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.1 C263.1 C264.1 C265.2 C266.2 C267.2 C268.2 C269.2 C270.2 C271.2 C272.1 C273.1 C274.2 C275.2 C276.2 C279.1 C280.2 C281.1 C282.1 C283.2 C284.2 C285.2 C286.2 C287.2 C288.2 C289.2 C290.2 C291.2 C295.1 C296.2 C297.2 C298.2 C299.1 C300.1 C301.1 C302.1 C303.1 C304.1 C305.2 C306.2 C307.2 C308.1 C309.2 C310.2 C311.2 C312.2 C313.2 C314.2 C315.2 C316.1 C317.2 C318.2 C319.2 C320.2 C321.2 C322.1 C323.1 C324.2 C325.2 C326.2 C327.2 C328.2 C329.2 C330.2 C331.1 C333.1 C334.2 C336.2 C337.2 C338.2 C339.2 C340.1 C341.2 C342.2 C343.2 C344.2 C345.2 C346.2 C347.2 C348.2 C349.1 C350.1 C352.1 C353.2 C354.2 C355.2 C356.2 C357.2 C358.1 C359.1 C360.1 C361.1 C362.1 C363.1 C364.1 C365.1 C366.1 C375.2 C377.1 C379.2 C380.1 C381.2 C382.1 C383.1 C384.1 C385.1 C388.1 C389.2 C390.2 C391.2 C392.2 C393.2 C394.1 C395.2 C396.1 C397.2 C398.1 C399.1 C400.1 C401.1 C402.2 C403.2 C404.2 C405.2 C406.2 C407.1 C408.2 C409.2 C410.1 C411.2 C412.1 C413.2 C414.2 C415.2 C416.2 C417.2 C418.2 C419.2 C420.1 C421.2 C424.2 C425.2 C426.2 C427.2 C428.2 C429.1 C430.1 C431.1 C432.1 C433.2 C434.2 C435.1 C436.2 C437.1 C438.2 C439.2 C444.2 C445.1 C446.2 C449.1 C450.2 C455.2 C457.2 C459.1 C461.1 C462.1 C465.2 C473.1 C474.1 C476.1 C477.1 C478.1 C480.1 C481.1 C482.2 C483.1 C484.2 C485.1 C486.2 C487.1 C488.1 C491.2 C493.2 C494.1 C495.1 C496.2 C497.2 C503.1 C504.2 C505.2 C506.2 C507.1 C509.1 C512.1 C513.2 C514.1 C515.2 C516.2 C517.2 C518.1 C519.2 C520.1 C521.2 C522.2 C524.1 C525.2 C526.1 C531.1 C532.1 C534.1 C535.1 C536.1 C537.1 C540.1 C541.1 C542.1 C543.1 C544.2 C545.1 C546.1 C547.2 C548.2 C549.1 C550.1 C634.1 C635.2 C640.1 C641.1 C642.2 C695.2 C696.2 C697.2 C698.2 C699.2 C700.2 C701.2 C702.2 C703.2 C704.2 C705.2 C706.2 C707.2 C708.2 C709.2 C710.2 C711.2 C712.2 C713.2 C714.1 C715.1 C716.1 C717.1 C718.1 C719.1 C720.1 C721.1 C722.1 C723.1 C724.1 C725.1 C726.1 C727.1 C798.1 C877.1 C878.1 C879.2 C880.2 C881.1 C882.1 C883.1 C884.1 C885.1 C886.1 C887.1 C888.1 C889.1 C890.1 C891.1 C892.1 C893.1 C894.1 C895.1 C896.1 C897.1 C898.1 C899.1 C900.1 C901.1 C902.1 C903.1 C904.1 C905.1 C906.1 C907.1 C908.1 C3218.1 C6036.1 C6037.1 C6038.1 C6039.1 C6040.1 C6041.1 C6056.2 C6057.2 C6058.2 C6064.2 C6112.2 C6113.2 C6114.2 C6115.2 C6116.2 C6117.2 C6118.2 C6119.2 C6120.2 C6121.2 C6122.2 C6123.2 C6124.2 C6126.2 C6128.2 C6129.2 C6130.1 C6131.2 C6132.2 C6133.2 C6134.2 C6135.2 C6136.2 C6137.2 C6138.1 C6139.1 C6140.1 C6147.2 C6148.2 C6154.2 C6155.2 C6156.2 C6158.2 C6159.2 C6160.2 CN2.1 CN2.2 CN2.5 CN2.E1 CN2.E2 CN3.2 CN3.5 CN3.8 CN3.11 CN3.17 CN3.E1 CN3.E2 CN3.E3 CN4.E1 CN4.E2 CN5.2(1-) CN6.E1 CN6.E2 CN7.C CN8.E1 CN8.E2 CN9.E1 CN9.E2 CN9.P4 CN9.P5 CN9.P6 CN9.P10 CN9.P12 CN9.S1 CN9.S4 CN9.S7 CN10.1(GND_1) CN10.3(GND_3) CN10.9(GND_9) CN10.15(GND_15) CN10.21(GND_21) CN10.27(GND_27) CN10.33(GND_33) CN10.39(GND_39) CN10.45(GND_45) CN10.51(GND_51) CN10.57(GND_57) CN10.71(GND_71) CN10.73(GND_73) CN10.75(GND_75) CN10.E1 CN10.E2 CN11.1(VSS47) CN11.2(VSS48) CN11.5(VSS46) CN11.6(VSS49) CN11.9(VSS45) CN11.10(VSS50) CN11.14(VSS51) CN11.15(VSS44) CN11.18(VSS52) CN11.19(VSS43) CN11.22(VSS53) CN11.23(VSS42) CN11.26(VSS54) CN11.27(VSS41) CN11.30(VSS55) CN11.31(VSS40) CN11.35(VSS39) CN11.36(VSS56) CN11.39(VSS38) CN11.40(VSS57) CN11.43(VSS37) CN11.44(VSS58) CN11.47(VSS36) CN11.48(VSS59) CN11.51(VSS35) CN11.52(VSS60) CN11.56(VSS61) CN11.57(VSS34) CN11.60(VSS62) CN11.61(VSS33) CN11.64(VSS63) CN11.65(VSS32) CN11.68(VSS64) CN11.69(VSS31) CN11.72(VSS65) CN11.73(VSS30) CN11.77(VSS29) CN11.78(VSS66) CN11.81(VSS28) CN11.82(VSS67) CN11.85(VSS27) CN11.86(VSS68) CN11.89(VSS26) CN11.90(VSS69) CN11.93(VSS25) CN11.94(VSS70) CN11.98(VSS71) CN11.99(VSS24) CN11.102(VSS72) CN11.103(VSS23) CN11.106(VSS73) CN11.107(VSS22) CN11.167(VSS21) CN11.168(VSS74) CN11.171(VSS20) CN11.172(VSS75) CN11.175(VSS19) CN11.176(VSS76) CN11.180(VSS77) CN11.181(VSS18) CN11.184(VSS78) CN11.185(VSS17) CN11.188(VSS79) CN11.189(VSS16) CN11.192(VSS80) CN11.193(VSS15) CN11.196(VSS81) CN11.197(VSS14) CN11.201(VSS13) CN11.202(VSS82) CN11.205(VSS12) CN11.206(VSS83) CN11.209(VSS11) CN11.210(VSS84) CN11.213(VSS10) CN11.214(VSS85) CN11.217(VSS9) CN11.218(VSS86) CN11.222(VSS87) CN11.223(VSS8) CN11.226(VSS88) CN11.227(VSS7) CN11.230(VSS89) CN11.231(VSS6) CN11.234(VSS90) CN11.235(VSS5) CN11.238(VSS91) CN11.239(VSS4) CN11.243(VSS3) CN11.244(VSS92) CN11.247(VSS2) CN11.248(VSS93) CN11.251(VSS1) CN11.252(VSS94) CN11.E1 CN11.E2 CN12.4 CN12.5 CN12.E1 CN12.E2 CN13.4 CN13.E1 CN13.E2 CN14.9(GND1) CN14.15(GND2) CN14.21(GND3) CN14.27(GND4) CN14.29(GND5) CN14.34(GND10) CN14.35(GND6) CN14.40(GND11) CN14.41(RSVD7) CN14.47(C_DAT) CN14.50(GND12) CN14.E1 CN14.E2 CN15.E1 CN15.E2 CN19.1(VSS47) CN19.2(VSS48) CN19.5(VSS46) CN19.6(VSS49) CN19.9(VSS45) CN19.10(VSS50) CN19.14(VSS51) CN19.15(VSS44) CN19.18(VSS52) CN19.19(VSS43) CN19.22(VSS53) CN19.23(VSS42) CN19.26(VSS54) CN19.27(VSS41) CN19.30(VSS55) CN19.31(VSS40) CN19.35(VSS39) CN19.36(VSS56) CN19.39(VSS38) CN19.40(VSS57) CN19.43(VSS37) CN19.44(VSS58) CN19.47(VSS36) CN19.48(VSS59) CN19.51(VSS35) CN19.52(VSS60) CN19.56(VSS61) CN19.57(VSS34) CN19.60(VSS62) CN19.61(VSS33) CN19.64(VSS63) CN19.65(VSS32) CN19.68(VSS64) CN19.69(VSS31) CN19.72(VSS65) CN19.73(VSS30) CN19.77(VSS29) CN19.78(VSS66) CN19.81(VSS28) CN19.82(VSS67) CN19.85(VSS27) CN19.86(VSS68) CN19.89(VSS26) CN19.90(VSS69) CN19.93(VSS25) CN19.94(VSS70) CN19.98(VSS71) CN19.99(VSS24) CN19.102(VSS72) CN19.103(VSS23) CN19.106(VSS73) CN19.107(VSS22) CN19.167(VSS21) CN19.168(VSS74) CN19.171(VSS20) CN19.172(VSS75) CN19.175(VSS19) CN19.176(VSS76) CN19.180(VSS77) CN19.181(VSS18) CN19.184(VSS78) CN19.185(VSS17) CN19.188(VSS79) CN19.189(VSS16) CN19.192(VSS80) CN19.193(VSS15) CN19.196(VSS81) CN19.197(VSS14) CN19.201(VSS13) CN19.202(VSS82) CN19.205(VSS12) CN19.206(VSS83) CN19.209(VSS11) CN19.210(VSS84) CN19.213(VSS10) CN19.214(VSS85) CN19.217(VSS9) CN19.218(VSS86) CN19.222(VSS87) CN19.223(VSS8) CN19.226(VSS88) CN19.227(VSS7) CN19.230(VSS89) CN19.231(VSS6) CN19.234(VSS90) CN19.235(VSS5) CN19.238(VSS91) CN19.239(VSS4) CN19.243(VSS3) CN19.244(VSS92) CN19.247(VSS2) CN19.248(VSS93) CN19.251(VSS1) CN19.252(VSS94) CN19.E1 CN19.E2 CN21.1 CN21.4 CN21.7 CN21.12 CN21.19 CN21.20 CN21.21 CN21.22 CN21.25 CN21.28 CN21.31 CN21.34 CN21.37 CN21.40 CN21.E1 CN21.E2 CN22.1(GND_1) CN22.7(GND_7) CN22.13(SDIO_DATA0) CN22.18(GND_18) CN22.19(DP_ML3N/SDIO_DATA3) CN22.33(GND_33) CN22.39(GND_39) CN22.45(GND_45) CN22.51(GND_51) CN22.57(GND_57) CN22.63(GND_63) CN22.69(GND_69) CN22.75(GND_75) CN22.E1 CN22.E2 CP2.2 CP3.2 CP4.2 CP5.2 CP7.2 CP10.2 CP11.2 CP12.2 CP13.2 CP18.2 CP19.2 CP20.2 D2.P D4.1(X1) D16.1(X1) D21.P D22.P D26.1(X1) D27.P D28.P D29.8(GND2) D32.P D33.P D34.P D35.P D36.P D37.P D45.8(GND2) D48.8(GND2) D49.8(GND2) D52.P D53.P D54.P D55.P D56.P D57.P D58.2 D59.P D60.P D61.P D62.P D65.P DR1.1 FB22.1 J1.4(GND1) J1.7(GND_DRAIN) J1.E1(GND2) J1.E2(GND3) J2.4(GND1) J2.7(GND_DRAIN) J2.E1(GND2) J2.E2(GND3) J4.4(GND1) J4.E1(GND2) J4.E2(GND3) J5.4(GND1) J5.E1(GND2) J5.E2(GND3) J9.3 LC1.2 LC2.2 LFB1.1 LFB2.1 LFB3.1 MH1.1 MH2.1 MH3.1 MH4.1 MH5.1 MH6.1 MH7.1 MH8.1 MH9.1 MH10.1 MH11.1 MH12.1 MH13.1 MQ1.3(S2) MQ1.4(S3) MQ1.5(S4) PC1.2 PC2.2 PC3.2 PC4.2 PC5.2 PC6.2 PC7.1 PC13.2 PC14.2 PC15.2 PC16.2 PC17.2 PC18.1 PC20.1 PC24.2 PC25.2 PC26.2 PC27.2 PC28.2 PC29.2 PC30.2 PC38.1 PC42.2 PC43.2 PC44.2 PC45.2 PC48.2 PC49.2 PC51.1 PC55.2 PC56.2 PC57.2 PC58.2 PC59.2 PC61.2 PC64.2 PC65.2 PC66.2 PC67.2 PC68.2 PC69.2 PCP2.2 PR6.2 PR21.1 PR22.1 PR24.1 PR26.1 PR30.1 PR50.1 PR56.1 PR57.1 PR59.1 PR69.2 PR77.1 PR80.1 PR83.2 PR93.1 PR107.1 PR115.1 PR120.2 PU3.6(GND) PU3.E1 Q4.2(S) Q6.1(S1) Q6.2(S2) Q6.3(S3) Q7.2(S) Q9.1(S1) Q9.2(S2) Q9.3(S3) Q10.2(S) Q11.2(S) Q12.2(S) Q13.2(S) Q23.1(S1) Q23.2(S2) Q23.3(S3) Q30.2(S) Q31.2(S) Q32.1(S1) Q32.2(S2) Q32.3(S3) Q36.2(GND) Q40.2(S) Q41.2(S) Q44.2(S) Q48.2(S) Q49.2(EMITTER) Q69.2(S) Q71.2(S) Q72.2(GND) Q76.2(S) Q77.2(S) Q78.2(S) Q79.2(S) Q80.2(S) Q81.2(S) Q83.2(S) Q84.2(S) Q85.2(S) Q86.2(S) Q88.2(S) R7.2 R19.1 R20.2 R23.1 R36.2 R39.1 R41.2 R44.2 R54.1 R55.1 R56.2 R73.2 R74.2 R75.1 R76.1 R77.1 R80.2 R81.1 R85.2 R87.1 R94.2 R99.1 R104.1 R108.2 R110.2 R111.1 R114.2 R119.2 R121.2 R148.2 R153.1 R159.2 R162.1 R163.1 R178.2 R180.1 R188.2 R190.2 R193.1 R198.1 R204.2 R207.1 R208.2 R213.1 R220.1 R224.1 R225.1 R226.2 R232.2 R246.2 R269.2 R270.2 R276.2 R279.1 R280.2 R281.1 R282.1 R285.2 R288.2 R289.2 R290.2 R318.1 R324.2 R326.1 R332.2 R333.2 R335.1 R339.2 R341.2 R345.2 R350.2 R355.2 R356.1 R361.2 R366.2 R367.2 R372.2 R375.1 R376.2 R377.2 R379.1 R381.2 R382.2 R383.2 R384.2 R387.2 R388.2 R395.2 R405.2 R411.2 R415.2 R482.2 R485.2 R492.2 R493.1 R517.2 R518.2 R531.2 R532.1 R534.2 R535.2 R536.1 R538.1 R539.1 R542.2 R543.1 R546.1 R548.1 R551.1 R556.1 R566.2 R567.1 R568.1 R569.1 R570.2 R571.2 R572.1 R581.2 R582.2 R584.2 R592.2 R598.1 R604.1 R607.1 R608.1 R612.1 R679.2 R680.2 R732.2 R736.2 R737.2 R738.2 R788.1 R802.1 R803.1 R811.1 R814.1 R816.1 R830.2 R839.2 R840.1 R841.2 R842.2 R847.1 R848.1 R849.1 R850.1 R851.1 R852.1 R857.2 R865.1 R868.2 R870.1 R874.1 R875.1 R882.1 R885.1 R888.1 R892.1 R894.1 R902.1 R908.2 R909.2 R910.1 R917.1 R920.1 R926.1 R930.1 R932.1 R1389.2 R1398.2 SW1.2 SW1.E1 SW1.E2 U1.A3(VSS_72) U1.A11(VSS_1) U1.A17(VSS_61) U1.A31(VSS_83) U1.A34(VSS_94) U1.A36(VSS_105) U1.A39(VSS_116) U1.A42(VSS_127) U1.A44(VSS_138) U1.A46(VSS_2) U1.A48(VSS_13) U1.A49(VSS_24) U1.AA45(VSS_35) U1.AA47(VSS_46) U1.AB3(VSS_57) U1.AB5(VSS_64) U1.AB6(VSS_65) U1.AB11(VSS_56) U1.AB38(VSS_58) U1.AB39(VSS_59) U1.AB41(VSS_60) U1.AB42(VSS_62) U1.AB43(VSS_63) U1.AC45(VSS_66) U1.AC49(VSS_67) U1.AD10(VSS_68) U1.AD11(VSS_69) U1.AD34(VSS_70) U1.AD37(VSS_71) U1.AE6(VSS_73) U1.AF37(VSS_74) U1.AF45(VSS_75) U1.AF47(VSS_76) U1.AG1(VSS_77) U1.AG3(VSS_79) U1.AG5(VSS_86) U1.AG9(VSS_87) U1.AG11(VSS_78) U1.AG38(VSS_80) U1.AG39(VSS_81) U1.AG41(VSS_82) U1.AG42(VSS_84) U1.AG43(VSS_85) U1.AH2(VSS_88) U1.AH37(VSS_89) U1.AH45(VSS_90) U1.AH49(VSS_91) U1.AJ2(VSS_92) U1.AJ3(VSS_93) U1.AK37(VSS_95) U1.AL2(VSS_96) U1.AL6(VSS_99) U1.AL45(VSS_97) U1.AL47(VSS_98) U1.AM2(VSS_100) U1.AM37(VSS_101) U1.AN2(VSS_102) U1.AN6(VSS_111) U1.AN38(VSS_103) U1.AN39(VSS_104) U1.AN41(VSS_106) U1.AN42(VSS_107) U1.AN43(VSS_108) U1.AN45(VSS_109) U1.AN49(VSS_110) U1.AR1(VSS_112) U1.AR2(VSS_114) U1.AR3(VSS_115) U1.AR7(VSS_117) U1.AR9(VSS_118) U1.AR11(VSS_113) U1.AT3(VSS_119) U1.AT5(VSS_122) U1.AT6(VSS_123) U1.AT7(VSS_124) U1.AT45(VSS_120) U1.AT47(VSS_121) U1.AU37(VSS_125) U1.AV3(VSS_128) U1.AV7(VSS_136) U1.AV11(VSS_126) U1.AV38(VSS_129) U1.AV39(VSS_130) U1.AV41(VSS_131) U1.AV42(VSS_132) U1.AV43(VSS_133) U1.AV45(VSS_134) U1.AV49(VSS_135) U1.AY3(VSS_137) U1.AY7(VSS_139) U1.B2(VSS_141) U1.B3(VSS_144) U1.B17(VSS_140) U1.B21(VSS_142) U1.B24(VSS_143) U1.B31(VSS_145) U1.B48(VSS_146) U1.BA1(VSS_147) U1.BA2(VSS_148) U1.BA45(VSS_3) U1.BA47(VSS_4) U1.BB3(VSS_6) U1.BB7(VSS_7) U1.BB11(VSS_5) U1.BC37(VSS_8) U1.BD3(VSS_9) U1.BD5(VSS_18) U1.BD6(VSS_19) U1.BD7(VSS_20) U1.BD38(VSS_10) U1.BD39(VSS_11) U1.BD41(VSS_12) U1.BD42(VSS_14) U1.BD43(VSS_15) U1.BD45(VSS_16) U1.BD49(VSS_17) U1.BE1(VSS_21) U1.BE2(VSS_22) U1.BF3(VSS_23) U1.BF7(VSS_27) U1.BF45(VSS_25) U1.BF47(VSS_26) U1.BG3(VSS_28) U1.BG7(VSS_30) U1.BG41(VSS_29) U1.BH37(VSS_31) U1.BJ1(VSS_32) U1.BJ2(VSS_33) U1.BJ3(VSS_34) U1.BJ7(VSS_40) U1.BJ41(VSS_36) U1.BJ43(VSS_37) U1.BJ45(VSS_38) U1.BJ49(VSS_39) U1.BM3(VSS_42) U1.BM5(VSS_45) U1.BM6(VSS_47) U1.BM7(VSS_48) U1.BM11(VSS_41) U1.BM45(VSS_43) U1.BM47(VSS_44) U1.BP1(VSS_49) U1.BP2(VSS_50) U1.BP3(VSS_51) U1.BP7(VSS_53) U1.BP43(VSS_52) U1.BR45(VSS_54) U1.BR49(VSS_55) U1.BT3(VSS_149) U1.BT7(VSS_154) U1.BT39(VSS_150) U1.BT41(VSS_151) U1.BT42(VSS_152) U1.BT43(VSS_153) U1.BU45(VSS_155) U1.BU47(VSS_156) U1.BV1(VSS_157) U1.BV2(VSS_159) U1.BV3(VSS_160) U1.BV7(VSS_161) U1.BV11(VSS_158) U1.BW3(VSS_162) U1.BW5(VSS_164) U1.BW6(VSS_165) U1.BW7(VSS_166) U1.BW37(VSS_163) U1.BY37(VSS_167) U1.BY45(VSS_168) U1.BY49(VSS_169) U1.C6(VSS_181) U1.C11(VSS_170) U1.C13(VSS_171) U1.C14(VSS_172) U1.C17(VSS_173) U1.C21(VSS_174) U1.C24(VSS_175) U1.C31(VSS_176) U1.C34(VSS_177) U1.C39(VSS_178) U1.C48(VSS_179) U1.C49(VSS_180) U1.CA3(VSS_182) U1.CA7(VSS_187) U1.CA38(VSS_183) U1.CA41(VSS_184) U1.CA42(VSS_185) U1.CA43(VSS_186) U1.CB37(VSS_188) U1.CB45(VSS_189) U1.CB47(VSS_190) U1.CC3(VSS_191) U1.CC7(VSS_192) U1.CE9(VSS_196) U1.CE37(VSS_193) U1.CE45(VSS_194) U1.CE49(VSS_195) U1.CG9(VSS_202) U1.CG37(VSS_197) U1.CG39(VSS_198) U1.CG43(VSS_199) U1.CG45(VSS_200) U1.CG47(VSS_201) U1.CH3(VSS_203) U1.CH5(VSS_204) U1.CJ9(VSS_207) U1.CJ37(VSS_205) U1.CJ42(VSS_206) U1.CK9(VSS_210) U1.CK45(VSS_208) U1.CK49(VSS_209) U1.CL37(VSS_211) U1.CL42(VSS_212) U1.CL49(VSS_213) U1.CM9(VSS_216) U1.CM45(VSS_214) U1.CM47(VSS_215) U1.CN3(VSS_217) U1.CN5(VSS_220) U1.CN37(VSS_218) U1.CN39(VSS_219) U1.CP9(VSS_221) U1.CR32(VSS_222) U1.CR37(VSS_223) U1.CR45(VSS_224) U1.CR49(VSS_225) U1.CT9(VSS_229) U1.CT37(VSS_226) U1.CT39(VSS_227) U1.CT42(VSS_228) U1.CU45(VSS_230) U1.CU47(VSS_231) U1.CU49(VSS_232) U1.CV3(VSS_233) U1.CV5(VSS_236) U1.CV9(VSS_237) U1.CV34(VSS_234) U1.CV35(VSS_235) U1.CY9(VSS_241) U1.CY41(VSS_238) U1.CY45(VSS_239) U1.CY49(VSS_240) U1.D13(VSS_242) U1.D17(VSS_243) U1.D31(VSS_244) U1.D44(VSS_245) U1.D49(VSS_246) U1.DA9(VSS_249) U1.DA10(VSS_247) U1.DA33(VSS_248) U1.DB32(VSS_250) U1.DB35(VSS_251) U1.DB38(VSS_252) U1.DB45(VSS_253) U1.DB47(VSS_254) U1.DB49(VSS_255) U1.DC3(VSS_256) U1.DC5(VSS_258) U1.DC6(VSS_259) U1.DC49(VSS_257) U1.DD37(VSS_260) U1.DD42(VSS_261) U1.DE6(VSS_274) U1.DE10(VSS_262) U1.DE13(VSS_263) U1.DE15(VSS_427) U1.DE17(VSS_264) U1.DE18(VSS_265) U1.DE20(VSS_266) U1.DE22(VSS_267) U1.DE23(VSS_268) U1.DE26(VSS_269) U1.DE28(VSS_270) U1.DE29(VSS_271) U1.DE33(VSS_272) U1.DE45(VSS_273) U1.DF13(VSS_275) U1.DF22(VSS_276) U1.DF28(VSS_277) U1.DF33(VSS_278) U1.DF35(VSS_279) U1.DF39(VSS_280) U1.DG6(VSS_288) U1.DG10(VSS_281) U1.DG12(VSS_282) U1.DG13(VSS_283) U1.DG15(VSS_284) U1.DG22(VSS_285) U1.DG23(VSS_286) U1.DG47(VSS_287) U1.DH1(VSS_289) U1.DH3(VSS_290) U1.DH5(VSS_292) U1.DH45(VSS_291) U1.DJ19(VSS_293) U1.DJ21(VSS_294) U1.DJ27(VSS_295) U1.DJ31(VSS_296) U1.DJ33(VSS_297) U1.DJ36(VSS_298) U1.DJ42(VSS_299) U1.DK3(VSS_300) U1.DK4(VSS_301) U1.DK6(VSS_303) U1.DK8(VSS_304) U1.DK49(VSS_302) U1.DL10(VSS_305) U1.DL13(VSS_306) U1.DL44(VSS_307) U1.DL47(VSS_308) U1.DM47(VSS_309) U1.DN15(VSS_310) U1.DN19(VSS_311) U1.DN24(VSS_312) U1.DN31(VSS_313) U1.DN36(VSS_314) U1.DN42(VSS_315) U1.DP45(VSS_316) U1.DR49(VSS_317) U1.DT1(VSS_318) U1.DT3(VSS_323) U1.DT6(VSS_328) U1.DT7(VSS_329) U1.DT8(VSS_330) U1.DT10(VSS_319) U1.DT15(VSS_320) U1.DT20(VSS_321) U1.DT27(VSS_322) U1.DT32(VSS_324) U1.DT37(VSS_325) U1.DT42(VSS_326) U1.DT49(VSS_327) U1.DU1(VSS_331) U1.DU2(VSS_334) U1.DU7(VSS_341) U1.DU10(VSS_332) U1.DU15(VSS_333) U1.DU20(VSS_335) U1.DU27(VSS_336) U1.DU32(VSS_337) U1.DU37(VSS_338) U1.DU48(VSS_339) U1.DU49(VSS_340) U1.DV2(VSS_342) U1.DV8(VSS_345) U1.DV44(VSS_343) U1.DV48(VSS_344) U1.DW1(VSS_346) U1.DW2(VSS_348) U1.DW7(VSS_355) U1.DW10(VSS_347) U1.DW20(VSS_349) U1.DW27(VSS_350) U1.DW44(VSS_351) U1.DW46(VSS_352) U1.DW48(VSS_353) U1.DW49(VSS_354) U1.E6(VSS_361) U1.E11(VSS_356) U1.E34(VSS_357) U1.E36(VSS_358) U1.E39(VSS_359) U1.E42(VSS_360) U1.F8(VSS_366) U1.F11(VSS_362) U1.F31(VSS_363) U1.F45(VSS_364) U1.F47(VSS_365) U1.G3(VSS_369) U1.G5(VSS_373) U1.G21(VSS_367) U1.G24(VSS_368) U1.G31(VSS_370) U1.G36(VSS_371) U1.G49(VSS_372) U1.H17(VSS_374) U1.H21(VSS_375) U1.H24(VSS_376) U1.H31(VSS_377) U1.H33(VSS_378) U1.H36(VSS_379) U1.H45(VSS_380) U1.H49(VSS_381) U1.J6(VSS_386) U1.J10(VSS_382) U1.J13(VSS_383) U1.J16(VSS_384) U1.J36(VSS_385) U1.K8(VSS_389) U1.K11(VSS_387) U1.K33(VSS_388) U1.L36(VSS_390) U1.L39(VSS_391) U1.L41(VSS_392) U1.L42(VSS_393) U1.L43(VSS_394) U1.L45(VSS_395) U1.L47(VSS_396) U1.M3(VSS_398) U1.M5(VSS_400) U1.M10(VSS_397) U1.M36(VSS_399) U1.N45(VSS_401) U1.N49(VSS_402) U1.P8(VSS_405) U1.P11(VSS_403) U1.P41(VSS_404) U1.R3(VSS_406) U1.R37(VSS_407) U1.T11(VSS_408) U1.T36(VSS_409) U1.T41(VSS_410) U1.T43(VSS_411) U1.T45(VSS_412) U1.T47(VSS_413) U1.U3(VSS_414) U1.U5(VSS_416) U1.U37(VSS_415) U1.V9(VSS_421) U1.V11(VSS_417) U1.V36(VSS_418) U1.V45(VSS_419) U1.V49(VSS_420) U1.W37(VSS_422) U1.Y9(VSS_426) U1.Y36(VSS_423) U1.Y38(VSS_424) U1.Y43(VSS_425) U2.1(VTTGND) U2.3(GND) U2.14(PGND) U2.E1 U3.E1(GND) U4.2(GND) U5.3(GND) U6.14(PGND) U6.E1(GND) U7.4(PGND) U7.8(AGND) U9.27(VSS1) U9.49(VSS2) U9.75(AVSS) U9.91(VSS3) U9.104(VSS4) U10.3(GND) U11.2(GND) U13.3(GND) U14.2(GND) U15.5(GND) U15.E1 U16.5(GND) U16.E1 U18.3(GND) U20.4(PGND) U20.8(AGND) U21.5(GND) U21.E1 U22.2(GND) U23.3(GND) U24.4(PGND) U24.8(AGND) U25.E1 U27.2(GND) U29.2(GND) U30.E1 U32.3(GND) U33.3(GND) U34.3(GND) U35.3(GND) U36.4(GND) U36_S.4(GND) U37.3(GND) U37.E1 U38.1(GND) U39.5(GND) U39.E1 U40.3(GND) U41.2(GND) U42.3(GND) U42.17(GNDX) U42.18(GNDX_1) U42.28(GND1) U42.E1 U43.1(A0/E0) U43.2(A1/E1) U43.3(A2/E2) U43.4(GND) U44.1(A0/E0) U44.2(A1/E1) U44.3(A2/E2) U44.4(GND) U49.4(GND) U49_1.4(GND) U50.3(GND) U51.E1 U52.1(GND) U54.3(GND) U55.5(GND) U55.E1 U56.3(GND) U57.3(GND) UC1.2 X1.2 X1.4 X2.2 X2.4
GND_EARTH: C440.2 C441.1 C442.1 C443.2 LC1.1 LC2.1 LFB1.2 LFB2.2 LFB3.2 LJ1.E1 LJ1.E2
P1.9V_VCT: C6038.2 C6039.2 C6040.2 C6041.2 R813.1 R814.2 U31.1(TCT1) U31.4(TCT2) U31.7(TCT3) U31.10(TCT4)
V1.05A_BYPASS: R111.2 U1.DJ15(VCC_V1P05EXT_1P05)
V1.05A_PWRGD: R205.2 U9.2(GPJ7) U24.7(PGOOD)
V1.8A_VR_PWRGD: R234.2 R327.1 R858.1 U51.4(POK)
V3.3_5A_EN: R227.1 R228.1 R898.2 R900.2
V3.3_5A_EN_EC: R227.2 U9.78(DAC2/TACH0B/GPJ2)
V3.3_5A_EN_IC: C26.2 R228.2 U7.11(BYP/LDO)
V3.3A_PWRGD: R37.2 R215.1 U9.33(GINT/CTS0#GPD5) U20.7(PGOOD)
V5A_PWRGD: R34.2 U7.7(PGOOD) U9.16(RXD/SIN0/PWUREQ#/BBO/SMCLK2ALT/)
VCC1_USB2.0: C76.2 C82.2 F5.2 J4.1(VBUS) R925.2 U27.1(VOUT)
VCC1_USB3.0: C6036.2 C6037.2 F2.2 J1.1(VBUS) R916.2 U11.1(VOUT)
VCC2_USB2.0: C407.2 C410.2 F6.2 J5.1(VBUS) R929.2 U29.1(VOUT)
VCC2_USB3.0: C323.2 C382.2 F3.2 J2.1(VBUS) R919.2 U22.1(VOUT)
VCC_8625: C544.1 C546.2 C547.1 FB12.1 FB18.1 R595.2 R596.2 R600.2 R605.1 R606.1 U42.13(VDDIOX) U42.14(VDDIOX_1) U43.8(VCC) U44.8(VCC)
VCC_SENSE: NS2.2(N2) PR70.2
VCCIN_AUX: C34.1 C35.1 C36.1 C37.1 C38.1 C39.1 C40.1 C41.1 C42.1 C43.1 C44.1 C45.1 C54.1 C59.1 C201.1 C202.1 C235.1 C237.1 C238.1 C239.1 C240.1 C241.1 C242.1 C243.1 C244.1 C245.1 C246.1 C247.1 C248.1 C249.1 C250.1 C251.1 C252.2 C253.2 C254.2 C255.1 C256.1 C257.1 C258.1 C259.1 C260.1 C261.1 C265.1 C266.1 C267.1 C268.1 C269.1 CP10.1 LPM5.2 PC52.2 PC64.1 PC65.1 PC66.1 PC67.1 PC68.1 PR60.1 PR64.1 PR117.2 PR119.1 R843.1 U1.AH1(VCCIN_AUX_1) U1.AJ1(VCCIN_AUX_12) U1.AL1(VCCIN_AUX_23) U1.AM1(VCCIN_AUX_31) U1.AN1(VCCIN_AUX_32) U1.AT9(VCCIN_AUX_34) U1.AT11(VCCIN_AUX_33) U1.AU10(VCCIN_AUX_35) U1.AV9(VCCIN_AUX_36) U1.AW10(VCCIN_AUX_2) U1.AY9(VCCIN_AUX_4) U1.AY11(VCCIN_AUX_3) U1.BA10(VCCIN_AUX_5) U1.BB9(VCCIN_AUX_6) U1.CH1(VCCIN_AUX_7) U1.CK11(VCCIN_AUX_8) U1.CL10(VCCIN_AUX_9) U1.CM11(VCCIN_AUX_10) U1.CN1(VCCIN_AUX_11) U1.CN10(VCCIN_AUX_13) U1.CP11(VCCIN_AUX_14) U1.CR10(VCCIN_AUX_15) U1.CT11(VCCIN_AUX_16) U1.CU10(VCCIN_AUX_17) U1.CV1(VCCIN_AUX_18) U1.CV11(VCCIN_AUX_19) U1.CW10(VCCIN_AUX_20) U1.CY11(VCCIN_AUX_21) U1.DC1(VCCIN_AUX_22) U1.DC11(VCCIN_AUX_28) U1.DE12(VCCIN_AUX_29) U1.DF12(VCCIN_AUX_30) U1.P13(VCCIN_AUX_24) U1.R12(VCCIN_AUX_25) U1.T13(VCCIN_AUX_26) U1.U12(VCCIN_AUX_27)
VCCIN_AUX_EN_R: R327.2 U6.19(EN)
VCCIN_AUX_FS: R309.2 U6.9(FSWSEL)
VCCIN_AUX_PG: R139.2 U6.4(PGOOD) U9.96(GPH3/ID3)
VCCIN_AUX_VCCSENSE: C6134.1 PR61.1 U1.BF9(VCCIN_AUX_VCCSENSE)
VCCIN_AUX_VSSSENSE: PR66.1 U1.BD9(VCCIN_AUX_VSSSENSE)
VCCIN_SENSE: PR51.2 PR55.2 U1.F17(VCCIN_SENSE)
VCCST_OVERRIDE_R: R288.1 U1.CE4(VCCST_OVERRIDE)
VCCST_PWRGD: Q12.3(D) R102.1
VCCST_PWRGD_MCP: R98.2 R102.2 U1.CF2(VCCST_PWRGD)
VCCST_PWRGD_TCSS: R280.1 U1.CE3(VCCSTPWRGOOD_TCSS)
VDD12: C548.1 C549.2 C550.2 FB11.2 L10.1 U42.19(VDD12)
VDDIO_8625: C531.2 C532.2 C540.2 FB3.2 FB9.2 R583.1 R588.2 R589.2 R594.2 R597.2 R603.2 U42.38(VDDIO) U42.50(VDDIO_1)
VDDRX: C541.2 C542.2 C543.2 FB11.1 U42.6(VDDRX)
VIN_LCD: C496.1 C497.1 C503.2 CP11.1 F7.1 L9.1 R540.2 R544.2 U37.13(VIN)
VSSIN_SENSE: PR83.1 PR106.2 U1.G17(VSSIN_SENSE)
8625_BLEN: R554.2 U42.23(ENBLT)
8625_PD#: C535.2 R589.1 U42.10(PD#)
8625_PWMO: R527.2 U42.12(PWMO)
8625_RST#: C534.2 R588.1 R1397.1 U42.9(RST#) U57.4(Y)
+V_ADP_IN: C185.1 C228.1 C408.1 C409.1 FB2.1 FB7.1 FB10.1 FB36.2 FB37.2 Q17.1(S1) Q17.2(S2) Q17.3(S3) R134.1 R170.2 R174.2 R261.2 R1392.2
+V_LED: C504.1 C505.1 C506.1 CN4.1 CP12.1 CP13.1 D46.N D50.N R520.1 R521.1
+VSYS_DCIN: C7.1 C19.1 C20.1 C118.1 C129.1 C188.1 C189.1 C190.1 C324.1 C330.1 C345.1 C346.1 C381.1 C473.2 C474.2 C6057.1 C6133.1 C6160.1 CN14.10(UIM_DATA) CN14.12(UIM_CLK) CN14.14(UIM_RESET) CN14.16(UIM_VPP) CN15.1 CN15.2 CN15.3 CN15.4 CP7.1 F7.2 FB36.1 FB37.1 MQ1.2(D1) PC1.1 PC2.1 PC3.1 PC4.1 PC5.1 PC6.1 PC16.1 PC17.1 PC24.1 PC25.1 PC26.1 PC27.1 PC28.1 PC29.1 PC30.1 PC43.1 PC44.1 PC45.1 PC48.1 PC49.1 PCP2.1 PR41.2 Q5.5(D1) Q5.6(D2) Q5.7(D3) Q5.8(D4) Q8.5(D1) Q8.6(D2) Q8.7(D3) Q8.8(D4) Q17.5(D1) Q17.6(D2) Q17.7(D3) Q17.8(D4) Q17.9(D5) Q22.5(D1) Q22.6(D2) Q22.7(D3) Q22.8(D4) Q29.5(D1) Q29.6(D2) Q29.7(D3) Q29.8(D4) R109.2 R134.2 R171.2 R329.2 U7.5(VIN) U20.5(VIN) U24.5(VIN)
A_MUTE_MIC: D52.N J7.6 R508.1
AC_PRESENT: R31.2 R324.1 R1396.2 U1.DE46(GPD1/ACPRESENT) U9.31(SMDAT5/PWM5/GPA5)
ADP_IN#: D73.P R1394.2 R1395.2
ADP_IN#_EC: R90.1 R1393.2 R1394.1 U9.28(PWM2/GPA2)
ALL_SYS_PWRGD_VRON: R328.2 U9.57(KSO17/SMISO/GPC5)
AU1_EN: PC18.2 PR17.1 R328.1 U3.29(VRON)
AU1_SET1: PR33.2 PR109.1 U3.10(SET1)
AU1_SET2: PR34.2 PR110.1 U3.9(SET2)
AU1_SET3: PR35.2 PR111.1 U3.8(SET3)
AU1_VR_RDY: PR68.2 R340.1 U3.30(VR_READY)
AUXN_LVDS: C187.1 R583.2 U42.1(DAUXN)
AUXP_LVDS: C196.1 R581.1 U42.2(DAUXP)
BKUP_BAT: CN5.1(1+) R222.2
BL_ADJ: R529.1 R586.1
BLCTL: R90.2 R545.2 U35.1(A)
BRD_ID1: R360.2 R372.1 U9.72(ADC6/DSR1#/GPI6)
BRD_ID2: R359.2 R361.1 U9.73(ADC7/CTS1#/GPI7)
CA_VREF_CA: R43.2 R128.2
CA_VREF_CB: C142.2 C156.2 CN19.164(VREFCA) R42.1 R45.2 R167.2 R193.2
CAM_ON: R578.2 R584.1 U9.77(TACH2B/GPJ1) U41.4(EN)
CFG_RCOMP: R41.1 U1.AD6(CFG_RCOMP)
CHAGER_IOUT: R304.1 U9.66(ADC0/GPI0)
CL_CLK: R464.2 U1.DV19(CL_CLK)
CL_DATA: R463.2 U1.DW19(CL_DATA)
CL_RST_N: R462.2 U1.DT19(C\L\_\R\S\T\_\N\)
CLKIN_XTAL_LCP: R207.2 R440.1 U9.24(PWM0/GPA0)
CNV_BRI_DT: R166.1 R286.2 R466.1
CNV_BRI_RSP: R158.1 R173.2
CNV_RECOMP: R226.1 U1.DT45(CNV_WT_RCOMP)
CNV_RGI_DT: R161.1 R181.1 R284.2
CNV_RGI_RSP: R164.1 R287.2
CNV_WR_0_DN: CN22.15(SDIO_DATA1) U1.DP44(CNV_WR_D0N)
CNV_WR_0_DP: CN22.17(MLDIR SENSE (I)/SDIO_DATA2) U1.DN44(CNV_WR_D0P)
CNV_WR_1_DN: CN22.9(SDIO_CLK) U1.DG42(CNV_WR_D1N)
CNV_WR_1_DP: CN22.11(SDIO_CMD) U1.DG44(CNV_WR_D1P)
CNV_WR_CLK_DN: CN22.21(SDIO_WAKE*/DP_ML3P) U1.DK44(CNV_WR_CLKN)
CNV_WR_CLK_DP: CN22.23(GND_23) U1.DJ44(CNV_WR_CLKP)
CNV_WT_0_DN: CN22.65(RESERVED_2ND_PERP1) U1.DV45(CNV_WT_D0N)
CNV_WT_0_DP: CN22.67(RESERVED_2ND_PERN1) U1.DU45(CNV_WT_D0P)
CNV_WT_1_DN: CN22.59(RESERVED_2ND_PETP1) U1.DU44(CNV_WT_D1N)
CNV_WT_1_DP: CN22.61(RESERVED_2ND_PETN1) U1.DT44(CNV_WT_D1P)
CNV_WT_CLK_DN: CN22.71(RESERVED/REFCLKP1) U1.DL42(CNV_WT_CLKN)
CNV_WT_CLK_DP: CN22.73(RESERVED/REFCLKN1) U1.DK42(CNV_WT_CLKP)
CPU_EOPIO_RCOMP: R842.1 U1.B14(RSVD_26)
CPU_POPIRCOMP: R80.1 U1.CJ41(PROC_POPIRCOMP)
CPU_SVIDALRT#: R242.2 R306.2 R307.2
CPU_SVIDCLK: R65.2 R235.2 U1.H2(VIDSCK)
CPU_SVIDDAT: R32.1 R239.2 R305.1 U1.H3(VIDSOUT)
CSCL/MSCL: R605.2 U42.25(CSCL/MSCL) U44.6(SCL)
CSDA/MSDA: R606.2 U42.24(CSDA/MSDA) U44.5(SDA)
CSI_RCOMP: R224.2 U1.B4(CSI_RCOMP)
DBG_PMODE: R867.2 R868.1 U1.DL15(DBG_PMODE)
DDR0_A_ALERT_N#: CN11.116(ALERT*) U1.BD46(N\C\/\D\D\R\0\_\A\L\E\R\T\_\N\)
DDR0_A_PARITY: CN11.143(PARITY) U1.BF39(NC/DDR0_PAR)
DDR1_B_ALERT_N: CN19.116(ALERT*) R44.1 U1.M49(NC/D\D\R\1\_\A\L\E\R\T\_\N\)
DDR1_B_PARITY: CN19.143(PARITY) R74.1 U1.P38(NC/DDR1_PAR)
DDR3VR_PWRGD: R70.1 U2.10(PGOOD) U9.32(PWM6/SSCK/GPA6)
DDR4_DRAMRST_R#: R301.1 R749.1 U1.DK47(D\R\A\M\_\R\E\S\E\T\_\N\)
DDR_CA_VREF: C48.2 R43.1 U1.C44(DDR0_VREF_CA)
DDR_COMP_0: R75.2 U1.D47(DDR_RCOMP_0)
DDR_COMP_1: R76.2 U1.E46(DDR_RCOMP_1)
DDR_COMP_2: R77.2 U1.C47(DDR_RCOMP_2)
DDR_PG_CTRL: U1.M39(DDR_VTT_CTL) U50.2(A)
DDR_VTT_PG_CTRL: R118.2 R120.2 R752.2 U50.4(Y)
DEVICE_PROCHOT#: C342.1 D67.P R122.2 R151.1 R259.2 U34.4(Y)
DISP_UTILS: R1398.1 U1.D2(DISP_UTILS)
DMIC_CLK0: CN2.7 R319.1 R368.1
DMIC_CLK0_PCH: R319.2 R347.2 U1.DG36(GPP_S6/SNDW4_CLK/DMIC_CLK0)
DMIC_CLK1: CN2.4 R334.1
DMIC_CLK1_PCH: R312.2 R334.2 U1.DF38(GPP_S4/SNDW3_CLK/DMIC_CLK1)
DMIC_CLK_CODEC: C486.1 R368.2 R407.2 R409.2
DMIC_DATA0: CN2.6 R320.1 R394.1
DMIC_DATA0_PCH: R320.2 R346.2 U1.DG34(GPP_S7/SNDW4_DATA/DMIC_DATA0)
DMIC_DATA1: CN2.3 R344.1 R432.1
DMIC_DATA1_PCH: R311.2 R344.2 U1.DD39(GPP_S5/SNDW3_DATA/DMIC_DATA1)
DMIC_DATA34_CODEC: R397.1 R399.2 R432.2
DMIC_DATA_CODEC: R394.2 R406.1 R410.2
DP_RCOMP: R23.2 U1.R2(DISP_RCOMP)
DSW_PWROK: R93.2 R857.1 U1.DR48(DSW_PWROK) U9.120(GPC4)
EC_MUTE#: R380.2 U9.30(SMCLK5/PWM4/GPA4) U23.1(A)
EC_SLP_S0IX_N: R157.1 R873.1 R874.2 U1.DT12(GPP_E6)
EC_SMI_LP_N: R156.2 U1.DT11(GPP_E7/CPU_GP1) U9.15(PLTRST#/ECSMI#/GPD4)
EC_VCC: R833.2 R834.2 U9.11(VCC)
EDID_SCL: R596.1 U42.29(DDC_SCL) U43.6(SCL)
EDID_SDA: R600.1 U42.30(DDC_SDA) U43.5(SDA)
EDP_AUX_DN: C187.2 U1.W4(DDIA_AUX_N)
EDP_AUX_DP: C196.2 U1.W3(DDIA_AUX_P)
EDP_DISP_UTIL: R522.1 R587.1
EDP_HPD: Q42.2(S) R591.1 R592.1 R828.2 U1.DW11(GPP_E14/DPPE_HPDA/DISP_MISCA)
EDP_HPD_8625: R593.1 U42.11(HPD)
EDP_HPD_CONN: Q42.3(D) R591.2 R593.2
EDP_TX_DN<0>: C152.2 U1.Y5(DDIA_TXN_0)
EDP_TX_DN<1>: C154.2 U1.Y1(DDIA_TXN_1)
EDP_TX_DN<2>: C6059.2 U1.V2(DDIA_TXN_2)
EDP_TX_DN<3>: C6061.2 U1.V3(DDIA_TXN_3)
EDP_TX_DP<0>: C153.2 U1.Y3(DDIA_TXP_0)
EDP_TX_DP<1>: C155.2 U1.Y2(DDIA_TXP_1)
EDP_TX_DP<2>: C6060.2 U1.V1(DDIA_TXP_2)
EDP_TX_DP<3>: C6062.2 U1.V5(DDIA_TXP_3)
EDRAM_OPIO_RCOMP: R841.1 U1.A14(RSVD_25)
EMMC_RCOMP: R163.2 U1.DU28(EMMC_RCOMP)
ENA: R553.2 U37.9(ENA)
ENPVCC/I2C_ADDR: R580.2 R594.1 U42.33(ENPVCC/I2C_ADDR)
ESPI_CLK_R: R437.2 U9.13(ESCK/LPCCLK/GPM4)
ESPI_CS_N_R: U1.CT45(GPP_A4/E\S\P\I\_\C\S\_\N\) U9.6(ECS#/LFRAME#/GPM5)
ESPI_IO_0_R: R433.1 U9.10(EIO0/LAD0/GPM0)
ESPI_IO_1_R: R434.1 U9.9(EIO1/LAD1/GPM1)
ESPI_IO_2_R: R435.1 U9.8(EIO2/LAD2/GPM2)
ESPI_IO_3_R: R436.1 U9.7(EIO3/LAD3/GPM3)
ESPI_RST_N: R840.2 U1.CR46(GPP_A6/E\S\P\I\_\R\E\S\E\T\_\N\) U9.22(ERST#/LPCRST#/GPD2)
EVDD10: C424.1 C425.1 C426.1 C427.1 C428.1 C433.1 C434.1 C435.2 C436.1 C437.2 C438.1 L8.2 R363.2 U30.3(AVDD10) U30.8(AVDD10_1) U30.22(DVDD10) U30.30(AVDD10_2)
FAN_BACK: CN13.2 D25.P R558.2 R559.2
FAN_PWMIN: CN13.3 R339.1 R829.2
FAN_PWMIN_GPU: CN14.4(GND7) R91.2 R345.1
FAN_VCC: C641.2 CN13.1 FB15.2
FB_CLAMP: CN14.3(RSVD1) R82.2 R1390.1
FB_CLAMP_C: R82.1 R322.1 U9.71(ADC5/DCD1#/GPI5)
FLASH_SPI_CLK: PR76.1 R388.1 R724.1 U1.DB42(SPI0_CLK)
FLASH_SPI_CS#: R29.1 R721.2 U1.DB43(S\P\I\0\_\C\S\0\_\N\) U49.1(CS*) U49_1.1(CS#)
FLASH_SPI_D<2>: R176.2 R725.1 U1.DF42(SPI0_IO2)
FLASH_SPI_D<3>: R175.1 R726.1 U1.DD41(SPI0_IO3)
FLASH_SPI_MISO: PR72.1 R728.1 U1.DD43(SPI0_MOSI)
FLASH_SPI_MOSI: PR75.1 R727.1 U1.DF43(SPI0_MISO)
FMISO: PR75.2 U9.103(FMISO) U36.2(SO/SIO1) U36_S.2(DO)
FMOSI: PR72.2 U9.102(FMOSI) U36.5(SI/SIO0) U36_S.5(DIO)
FPS_INT_N: R870.2 U1.DV11(GPP_E3/CPU_GP0)
FSCE#: R29.2 U9.101(FSCE#) U36.1(CS#) U36_S.1(CS#)
FSCK: PR76.2 U9.105(FSCK) U36.6(SCLK) U36_S.6(SCK)
GC6_FB_EN: R125.2 R421.2 R1391.2
GFX_CLK_REQ#: CN14.7(CLKREQ#) R8.2 U1.DP36(GPP_D8/S\R\C\C\L\K\R\E\Q\3\_\N\)
GFX_PCIE_CLK_N: CN14.11(REFCLK-) U1.CK3(CLKOUT_PCIE_N3)
GFX_PCIE_CLK_P: CN14.13(REFCLK+) U1.CK4(CLKOUT_PCIE_P3)
GPD_7: R865.2 R866.1 U1.DC47(GPD7)
GPP_C_5_SML0ALERTB: R644.1 U1.DP22(GPP_C5/S\M\L\0\A\L\E\R\T\_\N\)
GPP_E11: PR29.1 PR30.2 U1.DV16(GPP_E11/SPI1_CLK/BK1/SBK1)
GPP_E12: PR37.1 PR56.2 U1.DW16(GPP_E10/SPI1_CS_N/BK0/SBK0)
GPP_J_0_CNV_GNSS_PA_BLANKING: R263.1 U1.DP29(GPP_F6/CNV_PA_BLANKING)
GPP_J_8_CNV_MFUART2_RXD: R274.1 U1.DT40(GPP_H8/I2C4_SDA/CNV_MFUART2_RXD)
GPP_J_9_CNV_MFUART2_TXD: R264.1 U1.DW40(GPP_H9/I2C4_SCL/CNV_MFUART2_TXD)
GPPC_B0_CORE_VID0_R: R216.2 R316.1 R317.2 R326.2 U6.18(VID0) U56.1(A)
GPPC_B0_CORE_VID_0: R216.1 U1.CL38(GPP_B0/CORE_VID0)
GPPC_B1_CORE_VID1_R: R231.2 R310.1 R313.2 R318.2 U6.17(VID1) U56.2(B)
GPPC_B1_CORE_VID_1: R231.1 U1.CJ38(GPP_B1/CORE_VID1)
GPPC_B2_UART_BT_WAKE#: CN22.20(UART_WAKE*/DP_AUXN) R4.2 R420.1 R877.2
GPPC_B2_VRALERT_N: R233.1 U1.CN38(GPP_B2/V\R\A\L\E\R\T\_\N\)
GPPC_B2_VRALERT_N_R: D67.N R233.2 R831.1 R832.2
GPPC_H_18_CPU_C10_GATE_N_R: R354.1 U1.DU40(GPP_H18/C\P\U\_\C\1\0\_\G\A\T\E)
GPU_ALL_PWRGD: R142.2 R221.1
GPU_EVENT: R144.2 R510.2
GPU_PWR_EN: R143.2 R509.2
GPU_PWR_EN_EC: R426.2 U9.113(CRX0/GPC0)
GPU_RST_EC: R516.1 U9.84(EGCLK/GPE3)
H_CATERR_3P3V_N: R373.2 U9.83(EGCS#/GPE2) U13.4(Y)
H_PECI_EC: R237.2 U1.CD5(PECI)
HDA_BITCLK: C488.2 R266.1 U25.6(BIT-CLK)

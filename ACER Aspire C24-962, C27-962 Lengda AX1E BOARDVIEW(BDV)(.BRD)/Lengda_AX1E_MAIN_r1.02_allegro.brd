# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ<30>: length 81.9
  TOP w0.076: U1.AD42 206.22,65.81 v1(206.22,65.81)
  TOP w0.109: CN19.41 v1(169.22,13.8)
  ART03 w0.087: v1(206.22,65.81) 206.22,65.81 206.22,65.7 206.62,65.31 206.62,64.86 206.3,64.55 206.3,61.53 202.63,57.86 200.36,57.86 200,57.5 198.78,57.5 198.36,57.09 198.36,53.15 196.77,51.56 192.24,51.56 184.23,43.54 178.74,43.54 168.2,33.01 168.2,28.14 168.8,27.55 168.8,25 168.53,24.74 168.53,21.52 168.66,21.39 169.02,21.39 169.22,21.18 169.22,19.96 169.14,19.88 168.96,19.88 168.88,19.96 168.88,20.85 168.79,20.94 168.62,20.94 168.53,20.85 168.53,16.05 168.75,15.84 168.75,13.85 168.87,13.72 169.15,13.72 v1(169.22,13.8)
M_B_DQ<31>: length 81.4
  TOP w0.076: v1(205.27,65.83) 205.27,65.83 U1.AE42
  TOP w0.109: v1(165,17.32) 165.97,18.29 CN19.28
  ART03 w0.087: v1(205.27,65.83) 205.27,65.71 204.91,65.35 204.91,64.83 205.2,64.54 205.2,63.19 201.83,59.81 198.8,59.81 198.67,59.94 192.38,59.94 189.91,57.46 189.91,52.17 183.23,45.49 177.97,45.49 165.63,33.14 165.63,28.23 165.85,28.01 165.85,24.96 166.61,24.2 166.61,23.82 166.53,23.73 166.33,23.73 166.25,23.64 166.25,23.47 166.33,23.38 166.53,23.38 166.61,23.3 166.61,23.12 166.53,23.04 166.33,23.04 166.25,22.95 166.25,22.78 166.33,22.69 166.53,22.69 166.61,22.6 166.61,22.43 166.53,22.34 166.33,22.34 166.25,22.26 166.25,22.08 166.33,22 166.53,22 166.61,21.91 166.61,21.74 166.53,21.65 166.33,21.65 166.25,21.57 166.25,21.39 166.33,21.31 166.46,21.31 166.61,21.15 166.61,20.73 165.47,19.58 165.47,17.75 165.03,17.32 v1(165,17.32)
M_B_DQ<32>: length 69.6
  TOP w0.075: 216.78,59.22 218.23,59.22
  TOP w0.076: 216.78,59.22 216.1,59.22 216.02,59.29 216.02,59.52 215.94,59.6 215.79,59.6 215.71,59.52 215.71,59.29 215.64,59.22 215.49,59.22 215.41,59.29 215.41,59.52 215.33,59.6 214.68,59.6 213.45,60.82 213.22,60.82 212.53,61.5 212.53,62.48 212.56,62.63 212.79,62.86 U1.J48 ; 219.66,54.59 219.66,57.78 218.23,59.22
  TOP w0.109: 219.66,54.59 219.43,54.36 219.43,53.79 219.97,53.25 219.97,51.47 220.19,51.26 220.72,51.26 220.88,51.41 220.88,53.21 220.16,53.93 220.16,54.94 220.41,55.19 v1(220.8,55.19) ; CN19.174 204.47,19.09 204.2,18.83 v1(203.98,18.83)
  ART03 w0.087: v1(220.8,55.19) 220.52,55.19 220.43,55.1 220.43,43.19 209.23,31.98 209.23,28.78 208.65,28.19 208.65,24.71 203.59,19.65 203.59,18.84 203.67,18.76 203.91,18.76 v1(203.98,18.83)
M_B_DQ<33>: length 70.7
  TOP w0.076: 219.42,54.75 219.42,57.78 218.24,58.96 215.08,58.96 214.61,59.43 213.4,60.64 213.15,60.64 212.37,61.42 212.37,62.51 212.4,62.68 212.4,62.7 212.4,62.71 212.42,62.75 212.42,63.22 212.42,63.59 U1.J45
  TOP w0.109: 219.42,54.75 219.11,54.43 219.11,53.57 219.6,53.08 219.6,51.01 219.8,50.81 220.98,50.81 221.25,51.07 221.25,53.44 v1(220.8,53.89) ; CN19.170 203.47,17.72 203.65,17.55 v1(203.98,17.55)
  ART03 w0.087: v1(220.8,53.89) 220.8,43.07 209.83,32.1 209.83,31.88 210.05,31.67 210.05,31.5 209.96,31.41 209.66,31.41 209.57,31.33 209.57,28.64 208.99,28.05 208.99,24.56 204.36,19.93 204.36,17.93 v1(203.98,17.55)
M_B_DQ<34>: length 68.3
  TOP w0.076: v1(220.8,55.84) 220.39,55.42 220.01,55.42 219.93,55.51 219.93,56.16 220,56.24 220.3,56.24 220.38,56.31 220.38,56.46 220.3,56.54 220,56.54 219.93,56.62 219.93,56.77 220,56.85 220.3,56.85 220.38,56.92 220.38,57.07 220.3,57.15 220.17,57.15 219.93,57.39 219.93,57.76 217.93,59.76 217.52,59.76 217.44,59.68 217.44,59.51 217.37,59.44 217.22,59.44 217.14,59.51 217.14,59.68 217.06,59.76 216.91,59.76 216.83,59.68 216.83,59.51 216.76,59.44 216.61,59.44 216.53,59.51 216.53,59.68 216.45,59.76 214.75,59.76 213.47,61.03 213.26,61.03 212.75,61.54 212.75,62.35 U1.J49
  TOP w0.109: v1(204.71,15.57) 204.71,16.06 204.37,16.4 203.59,16.4 203.22,16.04 CN19.169
  ART03 w0.087: v1(204.71,15.57) 204.72,15.58 204.72,19.8 209.34,24.42 209.34,27.91 210.41,28.98 210.41,32.2 221.19,42.98 221.19,55.33 220.8,55.72 v1(220.8,55.84)
M_B_DQ<35>: length 69
  TOP w0.076: 221.25,59.63 219.58,59.63 218.23,60.98 215.88,60.98 215.18,61.68 215.18,61.87 214.62,62.44 214.62,63 214.06,63.56 U1.G47
  TOP w0.109: v1(225.35,55.83) 225.35,56.62 222.35,59.63 221.25,59.63 ; v1(207.79,17.64) 207.79,17.14 207.61,16.96 207.09,16.96 206.98,17.07 206.98,17.77 206.87,17.87 206.65,17.87 206.54,17.75 206.54,17.07 206.43,16.96 206.04,16.96 205.83,17.16 205.83,17.97 206.47,18.61 CN19.182
  ART03 w0.087: v1(225.35,55.83) 223.33,53.81 223.33,42.04 214.27,32.97 214.27,28.12 213.51,27.37 213.51,25.34 208.21,20.04 208.21,18.07 v1(207.79,17.64)
M_B_DQ<36>: length 69.7
  TOP w0.076: U1.J47 212.79,63.51 213.01,63.28 213.06,63.02 213.03,62.87 212.98,62.82 212.99,62.63 213.06,62.44 213.06,62.11 212.95,62 212.95,61.58 213.32,61.21 213.53,61.21 213.54,61.2 213.54,61.2 214.81,59.93 218.01,59.93 v1(220.78,57.15)
  TOP w0.109: CN19.173 204.22,14.24 204.37,14.39 v1(204.72,14.39)
  ART03 w0.087: v1(204.72,14.39) 205.02,14.39 205.1,14.47 205.1,19.69 210.27,24.86 210.27,27.49 210.58,27.79 210.58,27.91 210.28,28.21 210.28,28.34 210.4,28.46 210.52,28.46 210.82,28.16 210.94,28.16 211.07,28.28 211.07,28.93 210.98,29.01 210.87,29.01 210.79,29.1 210.79,29.27 210.87,29.36 210.98,29.36 211.07,29.45 211.07,29.62 210.98,29.71 210.87,29.71 210.79,29.79 210.79,29.97 210.87,30.05 210.98,30.05 211.07,30.14 211.07,30.31 210.98,30.4 210.87,30.4 210.79,30.49 210.79,30.66 210.87,30.75 210.98,30.75 211.07,30.83 211.07,31.01 210.98,31.09 210.87,31.09 210.79,31.18 210.79,31.35 210.87,31.44 210.98,31.44 211.07,31.53 211.07,31.7 210.98,31.79 210.87,31.79 210.79,31.87 210.79,32.05 210.87,32.13 210.98,32.13 211.07,32.22 211.07,32.38 221.54,42.85 221.54,55.46 221.33,55.67 221.33,57.86 221.13,58.07 220.61,58.07 220.41,57.87 220.41,57.38 220.64,57.15 v1(220.78,57.15)
M_B_DQ<37>: length 69.2
  TOP w0.076: 221.34,56.9 221.34,57.1 220.88,57.56 220.61,57.56 217.98,60.18 214.79,60.18 213.61,61.36 213.6,61.36 213.6,61.37 213.39,61.37 213.14,61.62 213.14,61.94 213.24,62.03 213.24,62.45 213.18,62.62 213.17,62.72 213.23,63.01 213.19,63.29 213.19,63.8 213.13,63.85 213.13,64.17 213.3,64.33 U1.G45
  TOP w0.109: 221.34,56.9 221.34,56.9 221.34,55.58 221.56,55.36 222.21,55.36 222.39,55.55 v1(222.39,56.71) ; v1(207.35,14.39) 207.77,13.97 207.77,13.57 207.72,13.52 CN19.187
  ART03 w0.087: v1(222.39,56.71) 222.65,56.45 222.65,42.39 213.02,32.76 213.02,28.13 211.96,27.07 211.96,24.9 206.64,19.58 206.64,17.79 207.21,17.23 207.21,16.11 206.92,15.82 206.92,14.81 v1(207.35,14.39)
M_B_DQ<38>: length 67.9
  TOP w0.076: U1.G48 214.44,62.71 214.44,62.36 214.9,61.9 214.9,61.71 215.81,60.79 218.16,60.79 219.75,59.2 221.25,59.2
  TOP w0.109: CN19.186 207.47,19.74 207.35,19.62 207.35,19.2 207.74,18.81 v1(207.79,18.81) ; 221.25,59.2 222.18,59.2 223.25,58.13 223.25,57.41 222.88,57.04 222.88,56.67 222.99,56.56 223.92,56.56 224.03,56.46 224.03,56.24 223.92,56.13 222.99,56.13 222.85,55.98 222.85,55.51 222.97,55.39 224.41,55.39 224.62,55.6 224.62,56.75 224.13,57.24 v1(223.97,57.24)
  ART03 w0.087: v1(223.97,57.24) 223.97,55.12 222.99,54.14 222.99,42.19 213.91,33.12 213.91,28.42 212.35,26.86 212.35,24.78 207.31,19.74 207.31,19.25 207.75,18.81 v1(207.79,18.81)
M_B_DQ<39>: length 66
  TOP w0.076: U1.E48 215.06,62.66 215.06,62.3 215.4,61.96 215.4,61.72 215.94,61.17 218.34,61.17 219.46,60.05 221.25,60.05
  TOP w0.109: 221.25,60.05 222.46,60.05 225.82,56.69 225.82,55.51 225.51,55.19 v1(225.36,55.19) ; v1(207.35,15.55) 206.72,14.93 CN19.183
  ART03 w0.087: v1(207.35,15.55) 208.15,16.35 208.15,17.28 208.6,17.73 208.6,19.84 213.93,25.18 213.93,27.2 214.65,27.91 214.65,32.78 223.67,41.8 223.67,53.5 225.36,55.19 v1(225.36,55.19)
M_B_DQ<40>: length 74.3
  TOP w0.076: v1(213.51,67.73) 213.38,67.81 U1.J38
  TOP w0.109: v1(208.99,18.84) 209.36,18.84 209.47,18.96 CN19.194
  ART03 w0.087: v1(213.51,67.73) 213.05,67.73 212.95,67.64 212.95,65.63 212.72,65.4 212.72,63.73 212.87,63.58 212.87,62.6 213.33,62.14 213.46,62.14 213.58,62.26 213.58,62.38 213.24,62.72 213.24,62.84 213.37,62.96 213.49,62.96 213.92,62.53 213.92,61.35 216.1,59.18 217.54,59.18 218.33,58.38 223.38,58.38 225.84,55.92 225.84,54.98 224.44,53.58 224.44,52.76 224.53,52.68 225.05,52.68 225.14,52.59 225.14,51.33 225.05,51.25 224.88,51.25 224.79,51.33 224.79,52.24 224.7,52.33 224.53,52.33 224.44,52.24 224.44,50.85 224.01,50.42 224.01,41.6 215,32.59 215,25.1 214.8,24.9 214.33,24.9 209.39,19.95 209.39,18.95 209.28,18.84 v1(208.99,18.84)
M_B_DQ<41>: length 73.3
  TOP w0.076: v1(214.42,67.1) 214.24,67.2 U1.G39
  TOP w0.109: v1(212.72,14.97) 212.54,14.97 211.72,14.15 CN19.203
  ART03 w0.087: v1(212.72,14.97) 212.81,14.88 213.17,14.88 213.49,15.2 213.49,16.73 213.94,17.18 213.94,20.45 215.36,21.87 216.14,21.87 218.78,24.51 218.78,28.08 219.07,28.38 219.07,32.77 227.46,41.15 227.46,49.21 228.18,49.94 228.18,53.02 228.86,53.69 228.86,56.36 229.2,56.7 229.2,58.44 227.97,59.66 226.82,59.66 225.25,61.23 223.41,61.23 222.41,62.22 219.53,62.22 218.43,63.33 217.92,63.33 216.66,64.59 216.66,65.15 214.71,67.1 v1(214.42,67.1)
M_B_DQ<42>: length 73.1
  TOP w0.076: U1.G38 214.23,67.85 v1(214.42,67.73)
  TOP w0.109: v1(212.72,13.8) CN19.207
  ART03 w0.087: v1(212.72,13.8) 213.82,14.89 213.82,16.42 214.34,16.95 214.34,20.24 215.53,21.43 216.14,21.43 219.22,24.51 219.22,27.7 220.06,28.54 220.06,33.34 227.77,41.05 227.77,49.02 228.51,49.76 228.51,52.87 229.15,53.51 229.15,56.16 229.49,56.49 229.49,58.68 228.14,60.03 226.93,60.03 225.44,61.51 223.66,61.51 222.64,62.54 219.68,62.54 218.45,63.77 218.01,63.77 217.12,64.66 217.12,65.11 214.49,67.73 v1(214.42,67.73)
M_B_DQ<43>: length 73
  TOP w0.076: v1(214.43,65.85) 214.4,65.84 U1.G42
  TOP w0.109: CN19.208 212.97,19.22 213.35,18.84 v1(213.48,18.84)
  ART03 w0.087: v1(214.43,65.85) 214.59,66.01 215.37,66.01 215.53,65.85 215.53,65.73 215.16,65.36 215.16,65.24 215.73,64.68 215.85,64.68 215.97,64.8 215.97,64.92 215.65,65.24 215.65,65.36 215.78,65.48 215.9,65.48 216.3,65.08 216.3,64.54 216.54,64.31 216.54,64.18 216.17,63.82 216.17,63.69 216.97,62.89 217.09,62.89 217.22,63.01 217.22,63.13 216.66,63.69 216.66,63.82 216.78,63.94 216.9,63.94 217.71,63.13 218.28,63.13 219.49,61.91 222.07,61.91 223.09,60.89 225.02,60.89 226.7,59.21 227.97,59.21 228.91,58.27 228.91,56.82 228.57,56.48 228.57,53.91 227.87,53.21 227.87,50.06 227.07,49.26 227.07,43.74 227.07,43.31 227.07,41.19 218.77,32.89 218.77,28.5 218.43,28.17 218.43,24.81 215.95,22.33 215.32,22.33 212.99,20 212.99,18.93 213.13,18.78 213.43,18.78 v1(213.48,18.84)
M_B_DQ<44>: length 74.5
  TOP w0.076: U1.J39 213.37,67.17 v1(213.51,67.1)
  TOP w0.109: CN19.190 208.47,18.19 v1(208.99,17.67)
  ART03 w0.087: v1(208.99,17.67) 208.99,17.61 208.51,17.13 208.51,16.66 208.67,16.5 208.91,16.5 208.98,16.57 208.98,16.96 209.07,17.05 209.24,17.05 209.33,16.96 209.33,16.49 209.42,16.41 209.63,16.41 209.78,16.56 209.78,19.87 214.47,24.56 214.94,24.56 215.34,24.96 215.34,32.45 224.35,41.46 224.35,49.54 224.54,49.73 225.5,50.7 225.5,54.08 226.19,54.76 226.19,56.07 223.53,58.73 218.42,58.73 217.72,59.43 216.56,59.43 214.93,61.06 214.93,61.82 212.93,63.83 212.93,65.36 213.12,65.55 213.12,66.94 213.27,67.1 v1(213.51,67.1)
M_B_DQ<45>: length 74.1
  TOP w0.076: v1(213.47,65.8) 213.46,65.85 U1.J42
  TOP w0.109: CN19.191 208.72,15.22 209.14,15.64 209.64,15.64 v1(209.72,15.55)
  ART03 w0.087: v1(213.47,65.8) 213.47,65.66 213.1,65.29 213.1,63.93 215.23,61.81 215.23,61.22 216.71,59.74 217.73,59.74 218.4,59.07 223.41,59.07 223.41,59.07 223.67,59.07 226.53,56.21 226.53,54.61 226.52,54.61 226.52,54.52 225.87,53.86 225.87,50.58 224.69,49.4 224.69,41.32 215.69,32.32 215.69,24.82 215.08,24.21 214.61,24.21 210.6,20.2 210.6,20.18 210.59,20.18 210.59,19.44 210.51,19.36 210.26,19.36 210.17,19.27 210.17,19.1 210.26,19.01 210.51,19.01 210.59,18.92 210.59,18.75 210.51,18.66 210.26,18.66 210.17,18.58 210.17,18.4 210.26,18.32 210.51,18.32 210.59,18.23 210.59,18.06 210.51,17.97 210.26,17.97 210.17,17.88 210.17,17.71 210.26,17.62 210.51,17.62 210.59,17.54 210.59,17.36 210.51,17.28 210.26,17.28 210.17,17.19 210.17,17.02 210.26,16.93 210.39,16.93 210.59,16.72 210.59,15.93 210.22,15.55 v1(209.72,15.55)
M_B_DQ<46>: length 72.5
  TOP w0.076: U1.G43 v1(214.43,65.19)
  TOP w0.109: CN19.204 211.97,18.52 212.82,17.67 v1(213.48,17.67)
  ART03 w0.087: v1(213.48,17.67) 213.03,17.67 212.68,18.02 212.68,20.2 215.16,22.68 215.8,22.68 216.7,23.58 218.1,24.98 218.1,28.24 218.45,28.6 218.45,33.02 226.76,41.33 226.76,49.39 227.52,50.14 227.52,53.27 228.28,54.03 228.28,56.6 228.62,56.94 228.62,58.14 227.96,58.79 226.05,58.79 225.9,58.94 225.9,59.07 225.99,59.15 225.99,59.28 225.87,59.4 225.74,59.4 225.65,59.31 225.53,59.31 225.41,59.43 225.41,59.56 225.5,59.64 225.5,59.77 225.38,59.89 225.25,59.89 225.16,59.8 225.04,59.8 224.28,60.57 222.88,60.57 222.46,60.99 221.32,60.99 221.24,60.9 221.24,60.56 221.15,60.47 220.98,60.47 220.89,60.56 220.89,60.9 220.8,60.99 220.63,60.99 220.54,60.9 220.54,60.56 220.46,60.47 220.28,60.47 220.2,60.56 220.2,60.9 219.25,61.85 218.31,61.85 217.69,62.47 216.9,62.47 215.3,64.07 215.3,64.64 214.75,65.19 v1(214.43,65.19)
M_B_DQ<47>: length 73.5
  TOP w0.076: U1.J43 213.44,65.23 213.46,65.16 213.47,65.15 v1(213.47,65.15)
  TOP w0.109: v1(209.72,13.8) CN19.195
  ART03 w0.087: v1(213.47,65.15) 213.47,65.12 213.51,65.08 213.51,63.8 214.45,62.86 214.83,62.86 215.52,62.17 215.52,61.38 216.86,60.04 217.83,60.04 218.45,59.42 223.82,59.42 227.06,56.18 227.06,54.5 226.3,53.74 226.3,50.53 225.62,49.85 225.62,41.77 216.06,32.21 216.06,24.56 215.38,23.87 214.78,23.87 210.94,20.03 210.94,15.26 210.85,15.18 210.29,15.18 210.2,15.09 210.2,14.92 210.29,14.83 210.85,14.83 210.94,14.74 210.94,14.57 210.85,14.48 210.29,14.48 210.2,14.4 210.2,14.22 210.29,14.14 210.67,14.14 210.75,14.05 210.75,13.6 210.58,13.43 210.1,13.43 v1(209.72,13.8)
M_B_DQ<48>: length 84.8
  TOP w0.076: v1(220.46,64.95) 220.01,65.4 219.67,65.4 219.5,65.57 219.44,65.57 219.43,65.58 217.61,65.58 217.36,65.83 217.14,65.83 217.03,65.79 216.76,65.79 U1.B43
  TOP w0.109: v1(214.56,13.8) 214.6,13.8 214.72,13.67 CN19.215
  ART03 w0.087: v1(214.56,13.8) 214.56,11.7 214.78,11.48 215.89,11.48 216.04,11.63 216.04,11.86 215.95,11.94 215.26,11.94 215.18,12.03 215.18,12.2 215.26,12.29 215.95,12.29 216.04,12.38 216.04,12.55 215.95,12.64 215.26,12.64 215.18,12.72 215.18,12.9 215.26,12.98 215.95,12.98 216.04,13.07 216.04,13.24 215.95,13.33 215.26,13.33 215.18,13.42 215.18,13.59 215.26,13.68 215.95,13.68 216.04,13.76 216.04,15.7 216.98,16.64 216.98,20.06 221.8,24.88 221.8,28.24 222.45,28.89 222.45,33.75 229.31,40.6 229.31,48.36 229.99,49.03 229.99,52.48 231.2,53.69 231.2,57.37 230.71,57.86 230.71,62.83 226.26,67.28 223.58,67.28 221.37,65.07 220.57,65.07 v1(220.46,64.95)
M_B_DQ<49>: length 86.2
  TOP w0.076: U1.D43 215.56,65.19 215.56,65.1 216.05,64.61 216.68,64.61 216.85,64.45 217.35,64.45 217.52,64.28 218.15,64.28 v1(218.43,64.56)
  TOP w0.109: CN19.229 218.22,13.89 v1(218.72,14.39)
  ART03 w0.087: v1(218.72,14.39) 220.35,16.01 220.35,19.72 222.51,21.88 223.3,21.88 225.37,23.94 225.37,31.48 226.39,32.51 226.39,34.91 231.41,39.93 231.41,43.17 232.65,44.4 232.65,51.94 233.43,52.72 233.43,58.57 232.85,59.15 232.85,63.5 228.43,67.93 228.43,69 226.98,70.44 222.03,70.44 221.59,70 220.62,70 219.68,69.06 219.68,67.4 218.9,66.61 217.31,66.61 217.13,66.44 217.13,65.86 v1(218.43,64.56)
M_B_DQ<50>: length 83.8
  TOP w0.076: v1(219.91,64.87) 219.36,65.41 217.4,65.41 217.27,65.54 U1.A43
  TOP w0.109: CN19.211 213.72,14.36 214.34,14.97 v1(214.56,14.97)
  ART03 w0.087: v1(219.91,64.87) 220.36,64.41 221.15,64.41 223.65,66.91 226.14,66.91 230.37,62.68 230.37,55.2 230.15,54.98 230.15,53.12 229.58,52.56 229.58,49.32 228.93,48.68 228.93,40.71 221.6,33.37 221.6,33.02 221.68,32.93 222.01,32.93 222.1,32.85 222.1,32.67 222.01,32.59 221.68,32.59 221.6,32.5 221.6,32.33 221.68,32.24 222.01,32.24 222.1,32.15 222.1,31.98 222.01,31.9 221.68,31.9 221.6,31.81 221.6,28.52 221.45,28.38 221.45,25.07 216.6,20.22 216.6,19.29 216.3,19 216.09,19 215.91,18.82 215.91,17.1 215.99,17.01 216.17,17.01 216.25,17.1 216.25,18.47 216.34,18.56 216.51,18.56 216.6,18.47 216.6,16.81 216.17,16.38 215.85,16.38 215.34,16.88 215.22,16.88 215.09,16.76 215.09,16.64 215.68,16.05 215.68,15.73 215.59,15.65 215.22,15.65 215.13,15.56 215.13,15.39 215.22,15.3 215.59,15.3 215.68,15.21 215.68,14.43 215.49,14.24 215.19,14.24 215.07,14.36 215.07,14.86 214.95,14.97 v1(214.56,14.97)
M_B_DQ<51>: length 85.8
  TOP w0.076: v1(221.7,66.97) 221.56,66.97 221.33,67.2 220.27,67.2 220.25,67.19 219.82,67.19 219.68,67.06 218.46,67.06 218.2,67.32 217.1,67.32 216.75,67.18 216.18,67.18 U1.C40
  TOP w0.109: CN19.228 217.97,19.35 v1(218.48,18.84)
  ART03 w0.087: v1(218.48,18.84) 218.37,18.84 218.11,19.11 218.11,19.58 221.92,23.4 222.98,23.4 224.43,24.85 224.43,31.82 225.48,32.88 225.48,35.23 230.52,40.27 230.52,43.61 231.22,44.31 231.22,44.43 230.62,45.03 230.62,45.15 230.75,45.28 230.87,45.28 231.47,44.68 231.59,44.68 231.77,44.86 231.77,48.9 231.69,48.98 231.32,48.98 231.23,49.07 231.23,49.24 231.32,49.33 231.69,49.33 231.77,49.42 231.77,49.59 231.69,49.68 231.32,49.68 231.23,49.76 231.23,49.94 231.32,50.02 231.69,50.02 231.77,50.11 231.77,50.28 231.69,50.37 231.32,50.37 231.23,50.46 231.23,50.63 231.32,50.72 231.69,50.72 231.77,50.8 231.77,50.98 231.69,51.06 231.32,51.06 231.23,51.15 231.23,51.32 231.32,51.41 231.69,51.41 231.77,51.5 231.77,51.67 231.69,51.76 231.32,51.76 231.23,51.84 231.23,52.02 231.32,52.1 231.69,52.1 231.77,52.19 231.77,52.48 232.36,53.06 232.36,58.3 231.93,58.74 231.93,63.17 227.17,67.93 227.17,68.44 226.59,69.03 220.67,69.03 220.37,68.73 220.37,68.16 220.59,67.94 220.71,67.94 221,68.23 221.12,68.23 221.24,68.11 221.24,67.98 220.96,67.7 220.96,67.57 221.08,67.45 221.2,67.45 221.89,68.14 222.11,68.14 222.48,67.78 222.48,67.61 221.84,66.97 v1(221.7,66.97)
M_B_DQ<52>: length 85.8
  TOP w0.076: U1.C43 216.16,65.25 217.33,65.25 217.33,65.25 218.87,65.25 v1(219.27,64.84)
  TOP w0.109: CN19.216 214.97,18.99 215.12,18.84 v1(215.48,18.84)
  ART03 w0.087: v1(215.48,18.84) 215.09,19.24 215.09,19.92 215.61,20.45 216.42,20.45 221.15,25.18 221.15,28.58 221.28,28.7 221.28,33.46 228.57,40.75 228.57,48.82 229.18,49.43 229.18,52.57 229.84,53.23 229.84,55.98 230.08,56.21 230.08,59.15 227.63,61.6 227.63,63.98 227.72,64.06 227.89,64.06 227.98,63.98 227.98,61.86 228.07,61.78 228.24,61.78 228.33,61.86 228.33,63.35 228.41,63.44 228.59,63.44 228.67,63.35 228.67,61.2 228.76,61.11 228.94,61.11 229.02,61.19 229.02,62.68 229.11,62.76 229.28,62.76 229.37,62.68 229.37,60.84 229.45,60.76 229.62,60.76 229.71,60.85 229.71,62.9 226.08,66.53 223.73,66.53 221.35,64.16 220.07,64.16 219.38,64.84 v1(219.27,64.84)
M_B_DQ<53>: length 87.2
  TOP w0.076: v1(218.48,66) 218.23,65.74 217.69,65.74 217.43,66.01 217.09,66.01 217.06,66 217.04,66 217.03,65.99 216.94,65.95 216.69,65.95 216.69,65.95 216.45,65.95 216.39,65.88 215.44,65.88 215.21,66.11 U1.D40
  TOP w0.109: CN19.212 213.97,18.2 214.08,18.09 214.6,18.09 214.85,17.84 214.85,16.61 214.74,16.5 214.52,16.5 214.41,16.61 214.41,17.54 214.3,17.65 214.08,17.65 213.97,17.54 213.97,16.34 214.21,16.1 215.21,16.1 215.48,16.38 v1(215.48,17.67)
  ART03 w0.087: v1(215.48,17.67) 215.42,17.61 214.92,17.61 214.68,17.85 214.68,20.13 215.46,20.91 216.06,20.91 220.18,25.03 220.18,28.01 220.98,28.82 220.98,33.58 228.2,40.8 228.2,48.98 228.83,49.6 228.83,52.7 229.56,53.43 229.56,56.11 229.79,56.35 229.79,58.98 227.29,61.48 227.29,64.9 226,66.2 223.9,66.2 222.53,64.82 222.53,63.64 222.36,63.47 222.24,63.47 222,63.7 221.88,63.7 221.76,63.57 221.76,63.45 221.99,63.22 221.99,63.1 221.69,62.8 221.12,62.8 221.03,62.88 221.03,63.57 220.95,63.66 220.77,63.66 220.69,63.57 220.69,62.88 220.6,62.8 219.78,62.8 218.89,63.7 218.89,65.6 v1(218.48,66)
M_B_DQ<54>: length 85.6
  TOP w0.076: v1(221.1,66.82) 220.89,67.03 219.88,67.03 219.74,66.88 218.4,66.88 218.13,67.15 217.16,67.15 216.91,67.05 216.72,66.86 U1.B40
  TOP w0.109: v1(218.52,17.62) 218.55,17.59 218.55,17.02 218.1,16.56 216.54,16.56 216.27,16.83 216.27,17.14 216.38,17.25 217.76,17.25 217.86,17.34 217.86,17.54 217.75,17.65 216.42,17.65 216.27,17.79 216.27,18.05 216.97,18.75 CN19.224
  ART03 w0.087: v1(218.52,17.62) 218.64,17.5 218.96,17.5 219.1,17.65 219.1,20.16 221.93,22.99 223.04,22.99 224.74,24.69 224.74,31.71 225.78,32.75 225.78,35.12 230.81,40.15 230.81,43.45 232.06,44.7 232.06,52.23 232.7,52.87 232.7,58.42 232.26,58.87 232.26,63.25 227.48,68.03 227.48,68.61 226.68,69.42 220.78,69.42 220.15,68.79 220.15,67.77 v1(221.1,66.82)
M_B_DQ<55>: length 84.4
  TOP w0.076: v1(220.54,66.65) 220.45,66.74 219.83,66.74 219.81,66.72 218.33,66.72 218.15,66.9 217.2,66.9 U1.A40
  TOP w0.109: v1(218.72,15.55) 218.31,15.97 217.43,15.97 217.19,15.72 217.19,15.47 217.3,15.36 217.87,15.36 217.98,15.25 217.98,15.03 217.87,14.93 217.3,14.93 217.19,14.82 217.19,12.55 CN19.225
  ART03 w0.087: v1(218.72,15.55) 219.34,15.55 219.98,16.19 219.98,16.59 219.89,16.68 219.53,16.68 219.44,16.77 219.44,16.94 219.53,17.03 219.89,17.03 219.98,17.11 219.98,20.06 222.44,22.52 223.38,22.52 225.07,24.21 225.07,31.61 226.08,32.62 226.08,35.01 231.1,40.03 231.1,43.28 232.35,44.54 232.35,52.09 233.06,52.8 233.06,58.52 232.56,59.03 232.56,63.37 228,67.93 228,68.77 226.82,69.96 223.93,69.96 223.68,69.71 220.69,69.71 219.97,68.98 219.97,67.22 v1(220.54,66.65)
M_B_DQ<56>: length 72.9
  TOP w0.076: U1.B35 216.96,69.67 217.4,69.81 218.41,69.81 218.55,69.67 220.32,69.67 v1(221.39,68.6)
  TOP w0.109: v1(220.72,15.55) 220.12,15.55 219.22,14.66 CN19.233
  ART06 w0.087: v1(220.72,15.55) 221.12,15.55 221.42,15.85 221.42,21.08 224.64,24.3 224.64,28.99 224.4,29.22 224.4,31.6 224.73,31.93 224.73,41.36 225.57,42.19 225.57,53.48 226.2,54.11 226.2,56.79 225.93,57.06 225.93,58.97 226.02,59.06 226.65,59.06 226.74,59.14 226.74,59.32 226.65,59.4 226.02,59.4 225.93,59.49 225.93,61 225.42,61.51 223.78,61.51 222.5,62.79 222.5,64.8 223.51,65.82 223.51,66.52 223.6,66.61 224.51,66.61 224.6,66.7 224.6,66.87 224.51,66.96 223.81,66.96 222.64,68.13 221.52,68.13 221.39,68.25 v1(221.39,68.6)
M_B_DQ<57>: length 74.1
  TOP w0.076: 223.91,69.04 221.25,69.04 220.44,69.84 218.62,69.84 218.48,69.98 217.32,69.98 216.88,69.82 216.32,69.82 216.12,69.74 215.74,69.74 U1.D35
  TOP w0.109: CN19.246 222.47,18.78 223.58,17.67 v1(224.01,17.67) ; 223.91,69.04 224.14,69.04 224.57,68.6 v1(224.57,68.54)
  ART06 w0.087: v1(224.01,17.67) 223.65,17.67 223.51,17.82 223.51,20.06 223.59,20.15 224.05,20.15 224.14,20.24 224.14,20.41 224.05,20.5 223.59,20.5 223.51,20.58 223.51,20.76 223.59,20.84 224.05,20.84 224.14,20.93 224.14,21.1 224.05,21.19 223.59,21.19 223.51,21.27 223.51,21.49 225.88,23.87 225.88,40.8 226.71,41.63 226.71,51.93 226.87,52.08 227.07,52.08 227.3,51.85 227.42,51.85 227.54,51.97 227.54,52.1 227.11,52.53 227.11,52.66 227.23,52.78 227.35,52.78 227.79,52.34 227.91,52.34 228.03,52.46 228.03,52.59 227.6,53.02 227.6,53.15 227.75,53.3 227.75,56.23 228.73,57.21 228.73,64.96 226.8,66.89 226.22,66.89 v1(224.57,68.54)
M_B_DQ<58>: length 71.7
  TOP w0.076: U1.A35 217.59,69.64 218.3,69.64 218.46,69.48 219.88,69.48 v1(220.76,68.6)
  TOP w0.109: v1(220.72,14.39) 220.69,14.39 220.22,13.92 CN19.237
  ART06 w0.087: v1(220.76,68.6) 220.76,68.02 220.94,67.84 222.66,67.84 223.32,67.19 223.32,65.95 222.19,64.83 222.19,62.63 223.62,61.2 225.1,61.2 225.62,60.68 225.62,56.84 225.82,56.64 225.82,54.56 224.43,53.17 224.43,50.43 224.52,50.34 224.99,50.34 225.07,50.26 225.07,50.08 224.99,50 224.52,50 224.43,49.91 224.43,49.74 224.52,49.65 224.99,49.65 225.07,49.56 225.07,49.39 224.99,49.3 224.52,49.3 224.43,49.22 224.43,49.04 224.52,48.96 224.99,48.96 225.07,48.87 225.07,48.7 224.99,48.61 224.52,48.61 224.43,48.52 224.43,32.06 223.62,31.25 223.62,29.58 224.34,28.86 224.34,24.42 220.98,21.07 220.98,16.58 220.13,15.73 220.13,14.98 v1(220.72,14.39)
M_B_DQ<59>: length 73.5
  TOP w0.076: v1(218.62,68.91) 218.39,69.14 218.27,69.14 218.13,69.28 217.7,69.28 217.36,69.03 217.1,69.03 216.93,69.09 216.75,69.09 216.7,69.07 216.64,69.05 216.36,69.05 216.18,69.12 215.37,69.12 215.21,68.97 U1.D38
  TOP w0.109: v1(219.48,18.84) 219.97,19.33 CN19.236
  ART06 w0.087: v1(218.62,68.91) 218.71,68.91 220.21,67.42 222.45,67.42 222.62,67.24 222.62,66.94 221.18,65.49 221.18,65.37 221.3,65.25 221.42,65.25 222.51,66.34 222.64,66.34 222.76,66.21 222.76,66.09 220.87,64.2 220.87,62.36 220.95,62.27 221.13,62.27 221.21,62.36 221.21,64.01 221.3,64.1 221.47,64.1 221.56,64.01 221.56,62.32 223.39,60.49 224.51,60.49 224.98,60.02 224.98,56.68 223.85,55.54 223.85,32.38 223.01,31.55 223.01,29.28 223.7,28.6 223.7,25.14 219.05,20.49 219.05,19.28 v1(219.48,18.84)
M_B_DQ<60>: length 73.6
  TOP w0.076: v1(219.27,68.91) 218.87,69.31 218.35,69.31 218.22,69.45 217.63,69.45 217.29,69.19 217.15,69.19 216.92,69.28 216.78,69.28 216.62,69.22 216.4,69.22 216.25,69.28 216.07,69.45 U1.C35
  TOP w0.109: CN19.232 218.97,18.12 219.42,17.67 v1(219.48,17.67)
  ART06 w0.087: v1(219.48,17.67) 219.48,17.62 219.67,17.43 220.42,17.43 220.62,17.63 220.62,20.53 220.54,20.61 220.37,20.61 220.27,20.51 220.27,18.16 220.19,18.08 220.02,18.08 219.93,18.17 219.93,20.71 224,24.79 224,28.72 223.32,29.4 223.32,31.42 224.14,32.24 224.14,55.39 225.29,56.54 225.29,60.33 224.78,60.84 223.48,60.84 221.85,62.46 221.85,64.83 223.05,66.03 223.05,67.14 222.57,67.62 220.34,67.62 219.27,68.69 v1(219.27,68.91)
M_B_DQ<61>: length 72.9
  TOP w0.076: 223.91,67.38 219.22,67.38 218.78,67.83 218.4,67.83 218.3,67.73 217.03,67.73 216.85,67.81 216.23,67.81 U1.C38
  TOP w0.109: v1(226.5,68.49) 226.5,68.16 225.72,67.38 223.91,67.38 ; CN19.249 v1(223.22,13.8)
  ART06 w0.087: v1(226.5,68.49) 226.58,68.49 229.63,65.43 229.63,52.38 227.75,50.5 227.75,40.87 226.78,39.9 226.78,30.21 228.16,28.84 228.16,27.57 227.05,26.46 227.05,23.18 225.23,21.37 225.23,18.95 224.71,18.42 224.71,16.09 223.91,15.3 223.91,14.22 223.49,13.8 v1(223.22,13.8)
M_B_DQ<62>: length 71.8
  TOP w0.076: 223.91,67.75 223.64,67.75 223.46,67.57 219.34,67.57 218.91,67.99 218.33,67.99 218.24,67.91 217.06,67.91 216.91,67.97 U1.B38
  TOP w0.109: CN19.245 v1(222.22,13.8) ; v1(225.84,68.49) 225.1,67.75 223.91,67.75
  ART06 w0.087: v1(222.22,13.8) 222.75,14.33 222.75,15.24 224.41,16.9 224.41,18.7 224.76,19.05 224.76,21.34 226.73,23.31 226.73,26.59 227.81,27.67 227.81,27.67 227.81,28.74 226.49,30.07 226.49,40.15 227.44,41.11 227.44,50.67 229.31,52.54 229.31,65.31 226.95,67.67 226.28,67.67 225.84,68.11 v1(225.84,68.49)
M_B_DQ<63>: length 71.3
  TOP w0.076: 223.91,68.07 223.78,68.07 223.77,68.06 223.72,68.06 223.45,67.79 219.37,67.79 219.01,68.16 218.98,68.16 218.98,68.16 218.26,68.16 218.26,68.16 218.17,68.07 217.26,68.07 U1.A38
  TOP w0.109: v1(225.2,68.54) 224.73,68.07 223.91,68.07 ; CN19.250 223.47,19.23 223.86,18.84 v1(224.01,18.84)
  ART06 w0.087: v1(225.2,68.54) 225.2,68.31 226.16,67.35 226.8,67.35 229.02,65.13 229.02,57.08 228.06,56.12 228.06,53.02 228.14,52.94 228.32,52.94 228.41,53.03 228.41,55.85 228.5,55.94 228.67,55.94 228.76,55.85 228.76,52.66 227.02,50.93 227.02,41.27 226.18,40.43 226.18,23.55 224.44,21.81 224.44,19.27 v1(224.01,18.84)
M_B_DQS_DN*<0>: length 75.7
  TOP w0.076: v1(205.01,57.73) 204.82,57.73 204.74,57.81 204.74,58.66 203.73,59.67 203.73,61.3 203.85,61.41 203.85,62.08 203.69,62.23 203.69,62.49 203.71,62.53 203.71,62.88 203.7,62.91 203.7,63.14 203.7,63.16 203.7,63.37 203.4,63.67 203.2,63.67 203.12,63.75 203.12,63.87 203.26,64.01 U1.AH46
  TOP w0.109: v1(171.89,14.43) 172.15,14.43 172.32,14.26 172.32,13.56 172.22,13.46 CN19.53
  ART03 w0.101: v1(205.01,57.73) 205.01,57.58 205.19,57.39 205.19,57.08 204.92,56.8 204.92,53.11 203.65,51.84 203.16,51.84 202.07,50.74 201.63,50.74 201.44,50.55 201.27,50.55 200.04,49.32 194.21,49.32 185.46,40.57 180.35,40.57 172.28,32.51 172.28,28.09 172.69,27.68 172.69,21.32 172.95,21.07 172.95,17.69 170.86,15.61 170.86,14.97 171.41,14.43 v1(171.89,14.43)
M_B_DQS_DN*<1>: length 83.9
  TOP w0.076: v1(203.44,66.46) 203.37,66.5 U1.AJ41
  TOP w0.109: v1(161.38,14.39) 161.6,14.6 161.84,14.6 161.86,14.58 161.86,13.58 161.72,13.44 CN19.11
  ART03 w0.101: v1(203.44,66.46) 203.08,66.1 203.08,64.27 201.74,62.92 188.58,62.92 185,59.34 185,53.67 185.12,53.55 185.12,52.26 181.51,48.65 176.48,48.65 162.14,34.31 162.14,27.42 161.95,27.23 161.95,24.43 162.2,24.18 162.2,14.75 161.89,14.45 161.44,14.45 v1(161.38,14.39)
M_B_DQS_DN*<2>: length 71.8
  TOP w0.076: U1.AC47 205.8,63.42 205.73,63.49 205.65,63.49 205.56,63.4 205.56,63.24 205.6,63.15 205.6,62.89 205.55,62.78 205.55,62.64 205.6,62.5 205.6,62.17 205.44,62.02 205.44,61.48 205.83,61.1 205.83,59.7 205.83,59.62 205.84,59.62 205.84,59.6 207.79,57.65 207.79,57.65 207.9,57.54 207.9,57.16 208,57.07 208,54.09 207.78,53.87 207.63,53.87 v1(207.4,53.65)
  TOP w0.109: CN19.74 177.47,19.58 177.59,19.47 177.59,19.41 177.59,19.41 177.59,18.59 177.96,18.22 178.37,18.22 v1(178.5,18.09)
  ART03 w0.101: v1(207.4,53.65) 207.62,53.42 207.62,53.03 205.79,51.2 205.79,50.51 205.68,50.39 205.68,49.22 202.04,45.59 196,45.59 186.9,36.48 184,36.48 178.27,30.75 178.27,25.05 177.48,24.25 177.48,23.71 177.75,23.44 178.05,23.44 178.15,23.34 178.15,23.14 178.05,23.03 177.75,23.03 177.48,22.76 177.48,22.31 177.75,22.04 178.05,22.04 178.15,21.94 178.15,21.74 178.05,21.64 177.75,21.64 177.48,21.36 177.48,20.91 177.75,20.64 178.05,20.64 178.15,20.54 178.15,20.34 178.05,20.24 177.75,20.24 177.48,19.97 177.48,18.41 177.79,18.09 v1(178.5,18.09)
M_B_DQS_DN*<3>: length 82.4
  TOP w0.076: v1(205.27,66.46) U1.AE41
  TOP w0.109: v1(166.48,18.84) 166.81,18.51 167.01,18.51 167.1,18.6 167.1,19.54 166.97,19.66 CN19.32
  ART03 w0.101: v1(205.27,66.46) 205.47,66.46 205.64,66.29 205.64,62.98 201.69,59.03 198.57,59.03 198.18,59.42 193.77,59.42 190.84,56.49 190.84,55.83 191.04,55.63 191.7,55.63 191.8,55.53 191.8,55.32 191.7,55.22 191.04,55.22 190.84,55.02 190.84,54.67 191.04,54.46 191.7,54.46 191.8,54.36 191.8,54.16 191.7,54.06 191.04,54.06 190.84,53.85 190.84,53.5 191.04,53.3 191.7,53.3 191.8,53.2 191.8,52.99 191.7,52.89 191.04,52.89 190.84,52.69 190.84,51.59 189.79,50.55 189.63,50.55 183.77,44.69 178.35,44.69 167.08,33.43 167.08,24.88 167.48,24.47 167.48,19.77 167.38,19.67 167.2,19.67 167.1,19.57 167.1,19.37 167.2,19.27 167.38,19.27 167.48,19.16 167.48,18.86 167.15,18.53 166.79,18.53 v1(166.48,18.84)
M_B_DQS_DN*<4>: length 68.8
  TOP w0.075: 221.2,58.22 221.18,58.22 221.12,58.28 220.33,58.28 220.33,58.28 220.21,58.28 220.16,58.33
  TOP w0.076: U1.H47 213.61,63.19 213.66,62.87 213.69,62.84 213.69,62.83 213.7,62.61 213.66,62.43 213.66,62.16 213.92,61.89 213.92,61.47 214.94,60.45 218.04,60.45 220.16,58.33
  TOP w0.109: v1(206.18,14.97) 206.18,14.91 206.1,14.82 205.68,14.82 205.35,14.49 205.35,13.76 205.22,13.64 CN19.177 ; v1(222.32,57.34) 222.05,57.61 221.9,57.61 221.72,57.44 221.58,57.44 221.42,57.59 221.42,57.76 221.59,57.92 221.59,58.07 221.44,58.22 221.2,58.22
  ART03 w0.101: v1(222.32,57.34) 222.08,57.59 221.99,57.59 221.88,57.47 221.88,56.11 222.24,55.75 222.24,42.54 211.78,32.08 211.78,28.98 211.88,28.88 212.06,28.88 212.34,28.61 212.34,28.16 212.06,27.89 211.88,27.89 211.51,27.52 211.51,25.03 206.23,19.76 206.23,17.99 205.8,17.55 205.8,17.26 205.9,17.16 206.53,17.16 206.81,16.88 206.81,16.43 206.53,16.16 205.9,16.16 205.8,16.06 205.8,14.97 205.94,14.84 206.05,14.84 v1(206.18,14.97)
M_B_DQS_DN*<5>: length 73.4
  TOP w0.076: U1.G41 v1(214.42,66.46)
  TOP w0.109: v1(211.51,18.24) 211.5,18.23 210.89,18.23 210.47,18.64 CN19.198
  ART03 w0.101: v1(214.42,66.46) 214.42,66.43 214.03,66.03 214.03,64.01 214.68,63.36 215.24,63.36 216.89,61.71 216.89,61.42 216.57,61.1 216.57,60.96 216.72,60.82 216.86,60.82 217.62,61.58 218.67,61.58 219.28,60.98 219.28,60.66 219.05,60.43 218.74,60.43 218.45,60.72 218.31,60.72 218.17,60.58 218.17,60.43 218.72,59.88 219.76,59.88 220.02,60.14 224.09,60.14 227.79,56.45 227.79,54.16 227.05,53.42 227.05,50.28 226.33,49.55 226.33,41.49 217.12,32.28 217.12,27.77 217.28,27.61 217.28,24.76 215.65,23.13 215.02,23.13 212.24,20.35 212.24,18.63 211.95,18.33 211.61,18.33 v1(211.51,18.24)
M_B_DQS_DN*<6>: length 85.3
  TOP w0.076: v1(219.87,66) 219.99,66.11 219.99,66.27 219.88,66.37 218.16,66.37 218,66.53 217.59,66.53 217.48,66.42 217.06,66.42 216.91,66.48 216.75,66.48 216.63,66.43 216.41,66.43 U1.C42
  TOP w0.109: v1(216.56,14.97) 216.39,14.8 216.24,14.8 216.05,14.99 215.85,14.99 215.72,14.86 215.72,14.7 215.93,14.49 215.93,14.34 215.84,14.25 215.84,13.58 215.72,13.46 CN19.219
  ART03 w0.101: v1(216.56,14.97) 216.87,14.66 217.04,14.66 217.4,15.03 217.4,19.86 221.79,24.25 222.82,24.25 223.68,25.1 223.68,26.42 223.57,26.52 222.91,26.52 222.64,26.8 222.64,27.25 222.91,27.52 223.57,27.52 223.68,27.62 223.68,27.7 223.68,27.82 223.57,27.92 223.01,27.92 222.74,28.2 222.74,28.62 223.04,28.92 223.57,28.92 223.68,29.02 223.68,29.52 222.87,30.33 222.87,31.89 223.14,32.17 223.76,32.17 223.86,32.27 223.86,32.47 223.76,32.57 223.14,32.57 222.87,32.85 222.87,33.6 223.52,34.25 223.95,34.25 224.43,33.77 224.56,33.77 224.7,33.91 224.7,34.07 224.21,34.56 224.21,34.94 229.72,40.45 229.72,45.3 230.93,46.51 230.93,48 230.52,48.41 230.52,52.4 231.6,53.49 231.6,58.08 231.23,58.45 231.23,62.88 226.34,67.77 223.52,67.77 221.33,65.57 220.29,65.57 v1(219.87,66)
M_B_DQS_DN*<7>: length 73
  TOP w0.076: U1.D36 215.87,68.49 216.44,68.49 216.74,68.37 216.93,68.37 217.07,68.42 217.49,68.42 217.6,68.32 218.19,68.32 218.2,68.32 219.05,68.32 219.05,68.32 219.18,68.32 219.54,67.97 222.88,67.97 223.07,68.16 223.07,68.38 v1(223.3,68.6)
  TOP w0.109: CN19.240 220.97,19.59 221.08,19.48 221.08,18.64 221.35,18.38 221.86,18.38 v1(222,18.24)
  ART06 w0.101: v1(222,18.24) 222.67,18.24 223.11,18.68 223.11,21.71 225.43,24.03 225.43,40.92 226.27,41.76 226.27,52.64 227.26,53.63 227.26,56.78 226.66,57.37 226.66,57.95 228.28,59.56 228.28,61.43 228,61.71 227.56,61.71 227.28,61.43 227.28,60.2 227.18,60.1 226.98,60.1 226.88,60.2 226.88,61.91 227.99,63.02 227.99,64.98 226.8,66.17 226.31,66.17 224.36,68.12 223.89,68.12 223.78,68 223.63,68 223.3,68.34 v1(223.3,68.6)
M_B_DQS_DP<0>: length 75.7
  TOP w0.076: v1(205.59,57.46) 205.48,57.36 204.86,57.36 204.54,57.68 204.54,58.48 203.54,59.48 203.54,59.62 203.53,59.63 203.53,61.51 203.66,61.64 203.66,62 203.51,62.16 203.51,62.49 203.5,62.49 203.5,62.53 203.52,62.57 203.52,62.83 203.5,62.86 203.5,63.31 203.45,63.36 U1.AH47
  TOP w0.109: v1(171.89,15.03) 171.93,15.03 172.59,14.37 172.59,12.65 CN19.55
  ART03 w0.101: v1(205.59,57.46) 205.37,57.25 205.37,57.01 205.09,56.73 205.09,53.03 203.72,51.66 203.24,51.66 202.15,50.57 201.7,50.57 200.17,49.03 194.33,49.03 185.58,40.28 180.47,40.28 172.58,32.38 172.58,28.21 172.98,27.81 172.98,21.45 173.24,21.19 173.24,17.57 171.16,15.49 171.16,15.09 171.53,14.72 171.63,14.72 171.89,14.98 v1(171.89,15.03)
M_B_DQS_DP<1>: length 84
  TOP w0.076: U1.AL41 v1(202.53,66.46)
  TOP w0.109: v1(161.38,14.99) 161.55,14.82 161.94,14.82 162.08,14.67 162.08,13.62 162.22,13.48 CN19.13
  ART03 w0.101: v1(202.53,66.46) 202.83,66.46 202.9,66.39 202.9,64.34 201.67,63.1 188.5,63.1 184.82,59.42 184.82,53.34 184.82,53.33 184.82,52.38 181.39,48.95 176.36,48.95 161.84,34.43 161.84,27.54 161.65,27.35 161.65,24.31 161.9,24.06 161.9,14.87 161.77,14.74 161.63,14.74 v1(161.38,14.99)
M_B_DQS_DP<2>: length 71.8
  TOP w0.076: v1(207.4,54.29) 207.62,54.06 207.7,54.06 207.81,54.17 207.81,56.99 207.72,57.08 207.72,57.46 207.71,57.47 205.65,59.52 205.65,59.54 205.65,59.54 205.65,59.77 205.65,59.77 205.65,61.02 205.26,61.41 205.26,62.09 205.25,62.09 205.4,62.25 205.4,62.47 205.36,62.61 205.36,62.82 205.4,62.93 205.4,63.11 205.37,63.2 205.37,63.48 205.57,63.68 205.57,63.78 U1.AC46
  TOP w0.109: v1(178.5,18.7) 178.29,18.48 178.07,18.48 177.86,18.7 177.86,19.52 177.97,19.64 CN19.76
  ART03 w0.101: v1(207.4,54.29) 207.8,53.89 207.8,52.96 205.97,51.13 205.97,49.1 202.17,45.29 196.13,45.29 187.02,36.19 184.12,36.19 178.57,30.63 178.57,24.93 177.77,24.13 177.77,23.84 177.87,23.73 178.17,23.73 178.45,23.46 178.45,23.01 178.17,22.74 177.87,22.74 177.77,22.64 177.77,22.44 177.87,22.33 178.17,22.33 178.45,22.06 178.45,21.61 178.17,21.34 177.87,21.34 177.77,21.24 177.77,21.04 177.87,20.94 178.17,20.94 178.45,20.66 178.45,20.21 178.17,19.94 177.87,19.94 177.77,19.85 177.77,18.53 177.91,18.39 178.19,18.39 v1(178.5,18.7)
M_B_DQS_DP<3>: length 82.4
  TOP w0.076: v1(206.2,66.46) U1.AD41
  TOP w0.109: CN19.34 167.47,19.67 167.37,19.56 167.37,18.49 167.12,18.25 166.48,18.25 v1(166.48,18.24)
  ART03 w0.101: v1(166.48,18.24) 167.28,18.24 167.78,18.74 167.78,24.59 167.37,25 167.37,33.3 178.47,44.4 183.89,44.4 191.02,51.52 191.02,52.61 191.12,52.71 191.77,52.71 191.98,52.92 191.98,53.27 191.77,53.47 191.12,53.47 191.02,53.58 191.02,53.78 191.12,53.88 191.77,53.88 191.98,54.08 191.98,54.43 191.77,54.64 191.12,54.64 191.02,54.74 191.02,54.94 191.12,55.05 191.77,55.05 191.98,55.25 191.98,55.6 191.77,55.81 191.12,55.81 191.02,55.91 191.02,56.42 193.84,59.25 198.1,59.25 198.5,58.85 201.76,58.85 205.82,62.91 205.82,66.22 206.06,66.46 v1(206.2,66.46)
M_B_DQS_DP<4>: length 68.8
  TOP w0.075: 221.2,58.49 221.18,58.49 221.12,58.43 220.27,58.43
  TOP w0.076: U1.H46 213.44,63.89 213.75,63.58 213.78,63.29 213.83,62.94 213.87,62.9 213.87,62.57 213.82,62.38 213.82,62.24 214.1,61.97 214.1,61.56 215.05,60.6 218.1,60.6 220.27,58.43
  TOP w0.109: 221.2,58.49 221.55,58.49 222.05,57.99 v1(222.32,57.99) ; CN19.179 205.72,13.64 205.64,13.72 205.61,13.77 205.61,13.87 205.61,13.87 205.61,14.38 205.79,14.56 206.01,14.56 206.03,14.53 206.04,14.53 v1(206.18,14.39)
  ART03 w0.101: v1(222.32,57.99) 222.21,57.88 221.87,57.88 221.59,57.6 221.59,55.99 221.94,55.63 221.94,42.67 211.48,32.21 211.48,28.86 211.76,28.59 211.94,28.59 212.04,28.49 212.04,28.28 211.94,28.18 211.76,28.18 211.21,27.64 211.21,25.16 205.94,19.88 205.94,18.11 205.5,17.68 205.5,17.13 205.78,16.86 206.41,16.86 206.51,16.76 206.51,16.56 206.41,16.46 205.78,16.46 205.5,16.18 205.5,14.85 205.81,14.54 206.03,14.54 v1(206.18,14.39)
M_B_DQS_DP<5>: length 73.5
  TOP w0.076: U1.J41 213.32,66.78 213.43,66.72 v1(213.51,66.46)
  TOP w0.109: CN19.200 210.97,19.73 210.74,19.49 210.74,18.75 211,18.49 211.17,18.49 v1(211.51,18.84)
  ART03 w0.101: v1(213.51,66.46) 213.59,66.54 213.72,66.54 213.85,66.41 213.85,63.94 214.61,63.19 215.16,63.19 216.71,61.64 216.71,61.49 216.4,61.18 216.4,60.89 216.64,60.64 216.93,60.64 217.7,61.4 218.6,61.4 219.1,60.9 219.1,60.73 218.97,60.61 218.82,60.61 218.53,60.9 218.24,60.9 217.99,60.65 217.99,60.36 218.65,59.7 219.83,59.7 220.1,59.96 221.08,59.96 221.2,59.85 223.97,59.85 227.49,56.33 227.49,54.28 226.76,53.55 226.76,50.4 226.03,49.67 226.03,41.61 216.82,32.4 216.82,27.65 216.99,27.49 216.99,24.88 215.53,23.42 214.9,23.42 211.95,20.47 211.95,20.28 211.84,20.18 211.7,20.18 211.6,20.08 211.6,19.88 211.7,19.77 211.84,19.77 211.95,19.67 211.95,18.75 211.82,18.63 211.72,18.63 v1(211.51,18.84)
M_B_DQS_DP<6>: length 85.4
  TOP w0.076: v1(220.5,66) 220.5,66.01 219.96,66.55 218.23,66.55 218.09,66.69 217.51,66.69 217.42,66.6 217.07,66.6 216.96,66.64 216.7,66.64 216.62,66.61 215.99,66.61 215.49,66.19 U1.D42
  TOP w0.109: CN19.221 216.22,13.47 216.11,13.58 216.11,14.14 216.34,14.37 v1(216.56,14.37)
  ART03 w0.101: v1(216.56,14.37) 217.16,14.37 217.7,14.91 217.7,19.74 221.91,23.95 222.94,23.95 223.97,24.98 223.97,26.55 223.7,26.82 223.04,26.82 222.93,26.92 222.93,27.12 223.04,27.22 223.7,27.22 223.97,27.5 223.97,27.66 223.97,27.66 223.97,27.95 223.7,28.22 223.13,28.22 223.03,28.32 223.03,28.5 223.16,28.62 223.7,28.62 223.97,28.9 223.97,29.64 223.16,30.45 223.16,31.77 223.26,31.87 223.88,31.87 224.16,32.15 224.16,32.59 223.88,32.87 223.26,32.87 223.16,32.97 223.16,33.48 223.64,33.95 223.82,33.95 224.31,33.47 224.68,33.47 224.99,33.79 224.99,34.19 224.51,34.68 224.51,34.82 230.01,40.32 230.01,45.18 231.22,46.39 231.22,48.12 230.81,48.53 230.81,52.28 231.9,53.36 231.9,58.21 231.53,58.57 231.53,63 226.47,68.06 223.91,68.06 223.79,67.94 223.44,67.94 221.25,65.75 220.75,65.75 220.7,65.8 220.7,65.8 v1(220.5,66)
M_B_DQS_DP<7>: length 72.9
  TOP w0.076: U1.C36 216.33,68.68 216.48,68.68 216.78,68.56 216.91,68.56 217.03,68.61 217.57,68.61 217.67,68.51 218.12,68.51 218.12,68.51 219.12,68.51 219.12,68.51 219.26,68.51 219.61,68.15 222.85,68.15 222.92,68.22 222.92,68.35 v1(222.66,68.6)
  TOP w0.109: CN19.242 221.47,19.59 221.35,19.46 221.35,18.75 221.46,18.65 221.8,18.65 v1(222,18.84)
  ART06 w0.101: v1(222.66,68.6) 222.78,68.6 223.56,67.83 224.24,67.83 226.19,65.88 226.68,65.88 227.7,64.86 227.7,63.14 226.58,62.03 226.58,60.08 226.86,59.81 227.3,59.81 227.58,60.08 227.58,61.31 227.68,61.41 227.88,61.41 227.98,61.31 227.98,59.68 226.37,58.07 226.37,57.25 226.96,56.66 226.96,53.75 225.98,52.76 225.98,41.88 225.14,41.04 225.14,24.15 222.81,21.83 222.81,21.55 222.71,21.45 222.49,21.45 222.39,21.35 222.39,21.14 222.49,21.04 222.71,21.04 222.81,20.94 222.81,20.74 222.71,20.64 222.49,20.64 222.39,20.53 222.39,20.33 222.49,20.23 222.71,20.23 222.81,20.13 222.81,19.93 222.71,19.83 222.58,19.83 222.48,19.72 222.48,19.52 222.58,19.42 222.71,19.42 222.81,19.32 222.81,18.8 222.55,18.53 222.31,18.53 v1(222,18.84)
M_B_DRAMRST: length 6.3
  TOP w0.127: CN19.108 185.97,21.85 v1(185.74,22.08)
  BOTTOM w0.102: v1(185.74,22.08) 185.59,22.23 183.42,22.23 183.02,21.83 C157.2 R300.1 182.81,22.76 R301.2
M_B_ODT<0>: length 97.9
  TOP w0.135: v1(199.25,8.6) 199.54,8.6 199.72,8.79 CN19.155 ; v1(208.93,65.19) 208.71,65.3 U1.V43
  ART03 w0.108: v1(199.25,8.6) 199.06,8.79 186.56,8.79 186.46,8.88 186.46,9.04 186.83,9.4 186.83,9.56 186.68,9.71 186.53,9.71 186.16,9.34 186.01,9.34 185.85,9.49 185.85,9.65 186.22,10.02 186.22,10.17 186.07,10.32 185.92,10.32 185.55,9.95 185.39,9.95 185.23,10.12 185.23,14.57 185.69,15.03 185.69,20.14 184.82,21.01 184.82,21.21 184.92,21.32 185.53,21.32 185.63,21.42 185.63,21.64 185.52,21.75 184.92,21.75 184.82,21.86 184.82,22.07 184.92,22.18 185.31,22.18 185.41,22.29 185.41,22.5 185.31,22.61 184.92,22.61 184.82,22.72 184.82,23.06 185.09,23.34 185.25,23.34 185.7,22.89 185.85,22.89 186,23.04 186,23.2 185.55,23.65 185.55,23.8 186.57,24.81 186.57,27.16 186.61,27.2 186.61,27.21 187.97,28.58 187.97,30.97 189.04,32.04 192.01,32.04 193.45,33.47 193.45,36.57 198.39,41.51 204.15,41.51 210.06,47.42 210.06,50.51 210.62,51.08 210.62,55.43 210.47,55.58 210.47,59.59 209.28,60.78 209.28,62.26 208.79,62.76 208.79,65.05 v1(208.93,65.19)
M_B_ODT<1>: length 93.3
  TOP w0.135: U1.V38 v1(208.92,67.78) ; v1(200.98,9.09) 201.22,9.33 CN19.161
  ART03 w0.102: v1(208.92,67.78) 209.37,67.34 209.37,66.87 209.3,66.81 209.3,64.78 209,64.48
  ART03 w0.108: 209,64.48 209,62.87 209.52,62.35 209.52,61.73 210.66,60.6 210.66,55.67 210.85,55.48 210.85,50.94 210.37,50.46 210.37,47.29 204.28,41.2 198.52,41.2 193.76,36.44 193.76,33.35 192.14,31.73 189.62,31.73 188.82,30.93 188.82,29.65 188.41,29.25 188.41,28.56 186.88,27.03 186.88,23.46 186.29,22.87 186.29,22.08 186.03,21.82 186.03,14.82 185.67,14.46 185.67,13.18 186.03,12.82 186.03,11.13 188.05,9.1 199.47,9.1 199.88,8.68 200.58,8.68 v1(200.98,9.09)
M_B_RAS_N: length 96.6
  TOP w0.076: 212.48,55.97 212.31,55.97 209.35,58.93 209.35,59.45 208.43,60.36 208.43,60.37 208.29,60.51 208.29,61.02 207.95,61.36 207.95,61.88 208.07,61.99 208.07,62.47 208.06,62.56 208.06,62.77 208.06,62.83 U1.V47
  TOP w0.135: v1(197.29,17.18) 197.3,17.2 198.75,17.2 199.8,16.16 200.93,16.16 201.06,16.28 201.06,16.7 200.03,17.72 199.36,17.72 198.97,18.11 CN19.152 ; v1(214.23,55.53) 214.23,55.78 214.04,55.97 213.66,55.97 213.53,55.83 213.53,54.98 213.36,54.82 213.09,54.82 212.99,54.93 212.99,55.83 212.85,55.97 212.48,55.97
  ART03 w0.108: v1(214.23,55.53) 214.23,55.77 214.76,56.3 215.11,56.3 215.32,56.09 215.32,55.27 215.22,55.16 214.71,55.16 214.6,55.06 214.6,54.84 214.71,54.73 215.22,54.73 215.32,54.62 215.32,51.81 215.52,51.61 215.52,50.49 215.41,50.38 215.15,50.38 215.04,50.27 215.04,50.05 215.15,49.95 215.41,49.95 215.52,49.84 215.52,49.62 215.41,49.51 214.94,49.51 214.84,49.41 214.84,49.19 214.95,49.08 215.41,49.08 215.52,48.97 215.52,48.76 215.41,48.65 214.94,48.65 214.84,48.55 214.84,48.33 214.95,48.22 215.41,48.22 215.52,48.11 215.52,47.89 215.41,47.79 214.94,47.79 214.84,47.68 214.84,47.47 214.95,47.35 215.41,47.35 215.52,47.25 215.52,47.03 215.41,46.92 214.94,46.92 214.84,46.82 214.84,46.6 214.95,46.49 215.41,46.49 215.52,46.38 215.52,46.08 205.78,36.34 205.63,36.34 205.24,36.73 204.95,36.73 201.9,33.68 201.9,33.53 202.05,33.37 202.2,33.37 205.02,36.19 205.17,36.19 205.32,36.04 205.32,35.88 202.22,32.78 202.07,32.78 201.96,32.88 201.81,32.88 201.66,32.73 201.66,32.58 201.76,32.47 201.76,32.32 201.61,32.17 201.45,32.17 201.35,32.27 201.2,32.27 201.05,32.12 201.05,31.96 201.15,31.86 201.15,31.71 200.82,31.38 200.34,31.38 199.56,30.59 199.56,29.69 199.45,29.58 198.9,29.58 198.79,29.48 198.79,29.26 198.9,29.15 199.45,29.15 199.56,29.04 199.56,28.83 199.45,28.72 198.9,28.72 198.79,28.61 198.79,28.4 198.9,28.29 199.45,28.29 199.56,28.18 199.56,27.38 199.45,27.28 199.09,27.28 198.99,27.17 198.99,26.95 199.09,26.85 199.45,26.85 199.56,26.74 199.56,26.52 199.43,26.39 198.95,26.39 198.81,26.25 198.81,24.96 196.91,23.06 196.91,22.84 197.35,22.41 197.35,22.06 197.12,21.83 197.12,21.61 197.23,21.5 197.56,21.5 197.67,21.39 197.67,21.17 197.56,21.07 197.23,21.07 197.12,20.96 197.12,20.74 197.23,20.63 197.56,20.63 197.67,20.53 197.67,20.31 197.56,20.2 197.23,20.2 197.12,20.09 197.12,19.88 197.23,19.77 197.56,19.77 197.67,19.66 197.67,19.45 197.56,19.34 197.23,19.34 197.12,19.23 197.12,18.21 197.23,18.1 197.6,18.1 197.71,18 197.71,17.78 197.6,17.67 197.23,17.67 197.12,17.56 197.12,17.35 v1(197.29,17.18)
M_B_WE_N: length 93.5
  TOP w0.135: U1.V41 v1(208.93,66.46) ; CN19.151 198.72,8.58 v1(198.55,8.4)
  ART03 w0.108: v1(198.55,8.4) 198.55,8.32 198.26,8.03 196.77,8.03 196.62,8.17 186.2,8.17 184.59,9.78 184.59,15.14 185.06,15.61 185.06,19.88 184.16,20.78 184.16,23.29 185.88,25.01 185.88,30.95 187.58,32.66 190.01,32.66 191.99,34.65 191.99,36.32 197.81,42.14 203.85,42.14 209.44,47.72 209.44,50.6 210.11,51.27 210.11,59.28 208.91,60.48 208.91,62.02 208.35,62.57 208.35,65.42 208.56,65.64 208.56,66.09 v1(208.93,66.46)
MDI0+: length 8.2
  TOP w0.101: v1(68.7,78.93) 68.5,78.73 U31.2
  BOTTOM w0.097: v1(68.7,78.93) 68.83,78.8 68.83,77.7 70.44,76.08 70.44,73.94 70.75,73.64 70.75,73.35 70.72,73.32 U30.1
MDI0-: length 8.2
  TOP w0.101: v1(69.3,78.93) 69.49,78.74 U31.3
  BOTTOM w0.097: v1(69.3,78.93) 69.17,78.8 69.17,77.84 70.79,76.23 70.79,74.09 71.09,73.78 71.09,73.35 71.12,73.32 U30.2
MDI1+: length 7.7
  TOP w0.101: v1(71.7,78.94) 71.47,78.71 U31.5
  BOTTOM w0.097: U30.4 71.92,73.32 71.95,73.35 71.95,73.98 72.19,74.22 72.19,76.85 71.79,77.25 71.79,78.84 v1(71.7,78.94)
MDI1-: length 7.7
  TOP w0.101: v1(72.3,78.94) 72.46,78.77 U31.6
  BOTTOM w0.097: U30.5 72.32,73.32 72.29,73.35 72.29,73.84 72.54,74.08 72.54,76.99 72.14,77.39 72.14,78.77 v1(72.3,78.94)
MDI2+: length 8.3
  TOP w0.101: U31.8 74.44,78.76 v1(74.63,78.94)
  BOTTOM w0.097: U30.6 72.72,73.32 72.76,73.36 72.76,73.72 73.19,74.15 73.19,76.61 74.76,78.18 74.76,78.82 v1(74.63,78.94)
MDI2-: length 8.3
  TOP w0.101: v1(75.23,78.94) 75.43,78.74 U31.9
  BOTTOM w0.097: v1(75.23,78.94) 75.1,78.81 75.1,78.04 73.53,76.47 73.53,74.01 73.1,73.58 73.1,73.34 73.12,73.32 U30.7
MDI3+: length 10.6
  TOP w0.101: v1(77.6,78.94) 77.41,78.75 U31.11
  BOTTOM w0.097: v1(77.6,78.94) 77.73,78.81 77.73,77.68 78,77.41 78,75.61 75.82,73.44 75.69,73.44 75.65,73.48 75.51,73.48 75.37,73.34 75.37,73.21 75.41,73.16 75.41,73.03 75.28,72.89 75.14,72.89 75.1,72.93 74.96,72.93 74.83,72.8 74.83,72.66 74.87,72.62 74.87,72.48 74.46,72.08 74.18,72.08 U30.9
MDI3-: length 10.6
  TOP w0.101: v1(78.2,78.94) 78.4,78.75 U31.12
  BOTTOM w0.097: v1(78.2,78.94) 78.07,78.81 78.07,77.82 78.34,77.56 78.34,75.47 74.6,71.73 U30.10
ME_FLASH: length 115.1
  TOP w0.109: v1(152.99,51.94) 152.37,51.94 R629.2
  ART06 w0.087: 139.66,55.48 139.05,56.08 139.05,57.17 134.01,62.22 125.28,62.22 123.78,63.71 117.98,63.71 116.75,64.94 115.73,64.94 115.17,64.37 106.51,64.37 106.22,64.66 106.22,64.91 105.46,65.67 100.6,65.67 99.99,65.06 90.1,65.06 87.96,62.91 78.86,62.91 77.15,64.62 74.2,64.62 73.49,63.91 64.59,63.91 63.65,62.97 62.44,62.97 v1(62.41,63)
  ART06 w0.102: 139.66,55.48 143.18,55.48 146.83,51.83 152.88,51.83 v1(152.99,51.94)
  BOTTOM w0.109: v1(62.41,63) 62.06,63 61.43,63.62 61.43,68.83 60.76,69.5 60.76,70.63 60.03,71.36 58.54,71.36 R165.2 57.72,71.25 U9.109
MFR_MODE_DET_STRAP: length 6.4
  TOP w0.075: R160.1 165.82,70.41 R162.2
  TOP w0.076: U1.DU33 169.4,70.81 168.76,70.81 168.58,70.9 166.34,70.9 R162.2
MIC2-VREFO: length 16.5
  TOP w0.203: U25.29 22.7,80.85 22.23,81.32 22.23,83.58 22.39,83.73 22.39,83.86
  TOP w0.305: D64.P 20.83,89.47 22.48,89.47 23.17,88.78 23.17,86.19 22.39,85.41 22.39,83.86
OPTION1_GPU: length 196.7
  ART06 w0.102: v1(69.34,56.81) 70.3,57.78 73.8,57.78 75.6,55.99 94.61,55.99 95.48,56.86 95.48,57.42 96.06,58 101.75,58 102.62,57.13 106.74,57.13 107.42,56.45 114.1,56.45 115.27,57.62 120.96,57.62 121.84,58.5 122.41,58.5 123.12,57.79 125.57,57.79 127.92,55.44 135.63,55.44 140.2,50.87 140.2,50.36 145.03,45.53 152.27,45.53 154.24,43.55 154.24,33.6 v1(153.96,33.32)
  BOTTOM w0.102: R62.2 215.67,33.27 214.17,34.77 208.12,34.77 205.96,36.93 190.22,36.93 188.23,34.94 182.54,34.94 180.38,32.78 154.5,32.78 v1(153.96,33.32) ; U9.123 54.72,65.65 54.11,65.04 54.11,63.71 57.5,60.32 62.5,60.32 65.41,57.41 68.74,57.41 v1(69.34,56.81)
OPTION2_GPU: length 195.2
  ART06 w0.102: v1(56.78,74.48) 56.74,74.44 56.74,71.22 61.86,66.09 61.86,64.2 62.53,63.53 63.55,63.53 64.16,64.13 73.26,64.13 74,64.87 77.22,64.87 78.92,63.16 87.71,63.16 89.81,65.26 99.91,65.26 100.54,65.89 105.55,65.89 106.28,65.15 107.97,65.15 108.44,64.68 115.06,64.68 115.54,65.15 116.96,65.15 118.19,63.92 127.45,63.92 128.36,63.01 133.48,63.01 134.04,62.44 134.06,62.44 139.32,57.18 139.32,56.21 139.84,55.7 143.25,55.7 146.88,52.07 152.36,52.07 152.72,52.43 154.2,52.43 v1(155.47,51.16)
  BOTTOM w0.075: R511.2 219.71,58.5 219.71,54.48
  BOTTOM w0.102: v1(56.78,74.48) 56.78,74.75 56.27,75.25 U9.99 ; 219.71,54.48 217.99,52.75 217.24,52.75 214.96,50.47 207.58,50.47 206.13,49.03 189.45,49.03 188,50.47 174.51,50.47 171.48,47.44 163.94,47.44 161.99,45.49 158.06,45.49 156.92,46.62 156.92,47.35 155.47,48.8 v1(155.47,51.16)
OUT_CLK+: length 3.3
  TOP w0.109: C373.2 58.35,81.26 58.35,82.68 58.24,82.79 R202.2 57.86,83.68 FIL8.4

# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Nets (continued)
HDA_RST#: R278.1 R371.1 R390.2
HDA_SDATAIN0: C430.2 R26.1 U25.8(SDATA-IN)
HDA_SDATAOUT: C431.2 R622.1 U25.5(SDATA-OUT)
HDA_SDOUT: Q15.3(D) Q18.2(S) R260.1 R619.1 U1.CY47(GPP_R2/HDA_SDO/I2S0_TXD)
HDA_SYNC: C429.2 R277.1 U25.10(SYNC)
HDMI_CLK+: CN3.10 D49.2(I/O2) D49.9(NC2) FIL8.3(DUMMY3) R217.1 R456.2
HDMI_CLK-: CN3.12 D49.1(I/O1) D49.10(NC1) FIL8.2(DUMMY2) R217.2 R457.2
HDMI_CTRLCLK: Q1.2(S) R11.2 R57.1
HDMI_CTRLDATA: Q2.2(S) R24.2 R49.1
HDMI_D0+: CN3.7 D49.5(I/O4) D49.6(NC4) FIL7.3(DUMMY3) R209.1 R454.2
HDMI_D0-: CN3.9 D49.4(I/O3) D49.7(NC3) FIL7.2(DUMMY2) R209.2 R455.2
HDMI_D1+: CN3.4 D48.4(I/O3) D48.7(NC3) FIL6.3(DUMMY3) R155.1 R452.2
HDMI_D1-: CN3.6 D48.5(I/O4) D48.6(NC4) FIL6.2(DUMMY2) R155.2 R453.2
HDMI_D2+: CN3.1 D48.1(I/O1) D48.10(NC1) FIL5.3(DUMMY3) R113.1 R450.2
HDMI_D2-: CN3.3 D48.2(I/O2) D48.9(NC2) FIL5.2(DUMMY2) R113.2 R451.2
HDMI_HPD: Q14.2(S) R446.2 R447.2 U1.CV42(GPP_A18/DDSP_HPDB/DISP_MISCB)
HP_OUT_L: R425.1 U25.32(HP-OUT-L)
HP_OUT_L_C: C499.2 D56.N FB35.1 J8.3
HP_OUT_R: R423.1 U25.33(HP-OUT-R)
HP_OUT_R_C: C500.2 D57.N FB34.1 J8.4
HPD_CONN: C232.2 CN3.19 D26.3(D3) Q14.3(D) R190.1 R447.1
HPOUT-JD: D53.N J8.6 R398.1
HSON: C422.2 U30.18(HSON)
HSOP: C423.2 U30.17(HSOP)
I2C_CLK1: R84.2 R126.2 U9.115(SMCLK1/GPC1)
I2C_CLK2_GPU: CN14.30(SMB_CLK) R88.2 U9.87(SMCLK0/GPF2)
I2C_DATA1: R86.2 R130.2 U9.116(SMDAT1/GPC2)
I2C_DATA2_GPU: CN14.32(SMB_DATA) R105.2 U9.88(SMDAT0/GPF3)
IINA: CN4.2 R219.2 R256.2 R271.2 R272.2
IINA0: R219.1 U37.1(ISEN  1)
IINA1: R256.1 U37.2(ISEN 2)
IINA2: R272.1 R540.1 U37.4(ISEN  3)
IINA3: R271.1 R544.1 U37.5(ISEN 4)
IMVP9_VR_READY: R340.2 U9.3(GPH7)
INPUT3VSEL: R104.2 R107.1 U1.DN49(INPUT3VSEL)
ISETA: CN20.2 CN20.4 CN20.6 CN20.8 R562.2 R563.2 R564.2 R565.2 R566.1 R571.1 R572.2 U37.6(ISET)
ISOLATEB: R247.1 R269.1 U30.20(ISOLATEB)
IST_TP_0: TP12.1 U1.BF11(IST_TP_0)
IST_TP_1: TP13.1 U1.BD11(IST_TP_1)
IST_TRIG_0: TP16.1 U1.BE10(IST_TRIG_0)
IST_TRIG_1: TP17.1 U1.BF10(IST_TRIG_1)
ISW: R552.2 U37.10(ISW)
KBC_FAN_SPEED: C640.2 Q72.3(OUT) R557.2 U9.47(TACH0A/GPD6)
KBC_FAN_SPEED_GPU: CN14.6(+1.5V_1) U9.48(TACH1A/TMA1/GPD7)
KBC_SPI_HOLD: R560.1 U36.7(HOLD#) U36_S.7(HOLD#)
KBC_WP_SPI: R561.1 U36.3(WP#/ACC) U36_S.3(WP#)
L_BKLT_EN: R405.1 R542.1 R545.1 U1.DL19(EDP_BKLTEN) U35.2(B)
L_BRIGHTNESS: R530.1 R531.1 R585.1 U1.DU19(EDP_BKLTCTL)
L_OUT+: C6121.1 CN6.2 D60.N R265.2
L_OUT-: C6122.1 CN6.1 D59.N R262.2
L_VDD_EN: R411.1 R579.2 U1.DN21(EDP_VDDEN)
LAN_CLK_REQ#: R12.2 U1.DP34(GPP_D7/S\R\C\C\L\K\R\E\Q\2\_\N\) U30.12(CLKREQB)
LAN_CMT: R502.2 U31.21(MCT2)
LAN_CMT1: R504.2 U31.15(MCT4)
LAN_CT: R501.2 U31.24(MCT1)
LAN_CT1: R503.2 U31.18(MCT3)
LAN_N1: C440.1 C441.2 C442.2 C443.1 R501.1 R502.1 R503.1 R504.1
LAN_PCIE_CLK_DN: U1.CL3(CLKOUT_PCIE_N2) U30.16(REFCLK_N)
LAN_PCIE_CLK_DP: U1.CL5(CLKOUT_PCIE_P2) U30.15(REFCLK_P)
LAN_PCIE_WAKE#: R243.2 R351.1 U30.21(LANWAKEB)
LAN_PLT_RST#: R358.1 U18.4(Y) U30.19(PERSTB)
LAN_RST: R362.2 U1.CF47(GPP_B17/GSPI0_MISO)
LAN_TX0N: FIL15.4(GND) R495.2 U31.22(MX1-)
LAN_TX0P: FIL15.1(UNB) R494.2 U31.23(MX1+)
LAN_TX1N: FIL16.1(UNB) R497.2 U31.19(MX2-)
LAN_TX1P: FIL16.4(GND) R496.2 U31.20(MX2+)
LAN_TX2N: FIL17.4(GND) R499.2 U31.16(MX3-)
LAN_TX2P: FIL17.1(UNB) R498.2 U31.17(MX3+)
LAN_TX3N: FIL18.4(GND) R505.2 U31.13(MX4-)
LAN_TX3P: FIL18.1(UNB) R500.2 U31.14(MX4+)
LAN_VDDEN: R198.2 R1399.2 U4.3(EN/ENB)
LAO1_CLKN: CN21.8 U42.35(TCK1N)
LAO1_CLKP: CN21.9 U42.34(TCK1P)
LAO1_DATAN0: CN21.24 U42.42(TA1N)
LAO1_DATAN1: CN21.2 U42.40(TB1N)
LAO1_DATAN2: CN21.5 U42.37(TC1N)
LAO1_DATAN3: CN21.10 U42.32(TD1N)
LAO1_DATAP0: CN21.23 U42.41(TA1P)
LAO1_DATAP1: CN21.3 U42.39(TB1P)
LAO1_DATAP2: CN21.6 U42.36(TC1P)
LAO1_DATAP3: CN21.11 U42.31(TD1P)
LAO_CLKN: CN21.30 U42.47(TCK0N)
LAO_CLKP: CN21.29 U42.46(TCK0P)
LAO_DATAN0: CN21.39 U42.54(TA0N)
LAO_DATAN1: CN21.36 U42.52(TB0N)
LAO_DATAN2: CN21.33 U42.49(TC0N)
LAO_DATAN3: CN21.27 U42.44(TD0N)
LAO_DATAP0: CN21.38 U42.53(TA0P)
LAO_DATAP1: CN21.35 U42.51(TB0P)
LAO_DATAP2: CN21.32 U42.48(TC0P)
LAO_DATAP3: CN21.26 U42.43(TD0P)
LCD_BA<1>: CN21.16 R933.1 U9.68(ADC2/GPI2)
LCD_BA<2>: CN21.17 R934.1 U9.70(ADC4/GPI4)
LCD_BA<GND>: CN21.18 PR120.1
LCD_VCC: C514.2 C515.1 C537.2 CN21.13 CN21.14 CN21.15 U39.7(VOUT2) U39.8(VOUT1)
LDO2-CAP: C472.2 U25.39(LDO2-CAP)
LDR: R547.1 U37.11(LDR)
LED0: TP41.1 U30.27(LED0)
LED1: TP40.1 U30.26(LED1/GPO)
LED2: TP39.1 U30.25(LED2)
LED_EN: R14.1 R546.2 R553.1 R554.1 U35.4(Y)
LED_ON: R14.2 U9.94(CRX1/SIN1/SMCLK3/GPH1/ID1)
LGATE1: PR16.1 U3.35(LGATE1)
LGATE2: PR48.1 U3.37(LGATE2)
LGATE3: PR74.1 PU3.7(LGATE)
LINE1_L: C471.1 U25.22(LINE1-L)
LINE1_R: C470.1 U25.21(LINE1-R)
LINE1L-VREFO: R391.2 U25.31(LINE1-VREFO-L)
LINE1R-VREFO: R392.2 U25.30(LINE1-VREFO-R)
LINE2_L: C378.1 U25.24(LINE2-L)
LINE2_R: C376.1 U25.23(LINE2-R)
LTB_CFG0_N: R106.2 R114.1 TP9.1 U1.AG6(CFG_0)
LTB_CFG1_N: R146.2 TP11.1 U1.AE7(CFG_1)
LTB_CFG2_N: TP14.1 U1.AG7(CFG_2)
LTB_CFG3_N: R147.2 R148.1 TP15.1 U1.AD9(CFG_3)
LTB_CFG4_N: R149.2 R159.1 TP18.1 U1.AE9(CFG_4)
LTB_CFG5_N: TP26.1 U1.AB9(CFG_5)
LTB_CFG6_N: TP27.1 U1.AJ6(CFG_6)
LTB_CFG7_N: TP28.1 U1.AB7(CFG_7)
LTB_CFG8_N: R169.2 R178.1 TP29.1 U1.V10(CFG_8)
LTB_CFG9_N: R250.2 R270.1 TP30.1 U1.AJ5(CFG_9)
LTB_CFG10_N: R283.2 R332.1 TP31.1 U1.Y10(CFG_10)
LTB_CFG11_N: R333.1 TP32.1 U1.AJ7(CFG_11)
LTB_CFG12_N: R336.2 R341.1 TP33.1 U1.AB10(CFG_12)
LTB_CFG13_N: R343.2 R366.1 TP34.1 U1.AL7(CFG_13)
LTB_CFG14_N: R367.1 TP42.1 U1.AL9(CFG_14)
LTB_CFG15_N: R376.1 TP43.1 U1.AJ9(CFG_15)
LTB_CFG_STB0_DN: TP44.1 U1.V6(CFG_16)
LTB_CFG_STB0_DP: TP45.1 U1.V7(CFG_17)
LTB_CFG_STB1_DN: TP46.1 U1.Y6(CFG_18)
LTB_CPU_JTAG_TCLK: R878.2 U1.P3(PROC_TCK)
LTB_CPU_JTAG_TDI: R133.1 R880.2 U1.K5(PROC_TDI)
LTB_CPU_JTAG_TDO: R131.1 R883.2 U1.K3(PROC_TDO)
LTB_CPU_JTAG_TMS: R132.1 R886.2 U1.P4(PROC_TMS)
LTB_CPU_JTAG_TRST_N: R890.2 U1.N1(P\R\O\C\_\T\R\S\T\_\N\)
LTB_OVERRIDE: D66.P D68.P Q88.3(D) R860.2
LTB_PCH_JTAG_TCLK: R135.1 R893.2 U1.R5(PCH_TCK)
LTB_PCH_JTAG_TDI: R137.1 R881.2 U1.K1(PCH_TDI)
LTB_PCH_JTAG_TDO: R141.1 R884.2 U1.K2(PCH_TDO)
LTB_PCH_JTAG_TMS: R887.2 R889.1 U1.N3(PCH_TMS)
LTB_PCH_JTAG_TRST_N: R891.2 U1.N5(P\C\H\_\T\R\S\T\_\N\)
LTB_PCH_JTAGX: R879.2 U1.N2(PCH_JTAGX)
M.2_BT_PCMCLK: CN22.8(PCM_CLK/I2S_SCK) R414.1
M.2_BT_PCMFRM_CRF_RST_N: CN22.10(PCM_SYNC/I2S_WS) R214.1 R415.1 R443.1
M.2_BT_PCMIN: CN22.12(PCM_IN/I2S_SD_IN) R416.1
M.2_BT_PCMOUT_CLKREQ0: CN22.14(PCM_OUT/I2S_SD_OUT) R213.2 R417.1
M_0_CSA1_N: CN11.162(S2*/C0) U1.BM42(DDRA_CS_1/NC)
M_0_CSB0_N: CN11.165(S3*/C1) U1.BP42(DDRB_CS_0/NC)
M_A_A0: CN11.144(A0) U1.BB48(NC/DDR0_MA0)
M_A_A1: CN11.133(A1) U1.BL49(NC/DDR0_MA1)
M_A_A2: CN11.132(A2) U1.BG38(DDRB_CA5/DDR0_MA2)
M_A_A3: CN11.131(A3) U1.BL45(NC/DDR0_MA3)
M_A_A4: CN11.128(A4) U1.BJ46(NC/DDR0_MA4)
M_A_A5: CN11.126(A5) U1.BG48(DDRA_CA0/DDR0_MA5)
M_A_A6: CN11.127(A6) U1.BE45(DDRA_CA2/DDR0_MA6)
M_A_A7: CN11.122(A7) U1.BG45(DDRA_CA4/DDR0_MA7)
M_A_A8: CN11.125(A8) U1.BG47(DDRA_CA3/DDR0_MA8)
M_A_A9: CN11.121(A9) U1.BE47(DDRA_CA1/DDR0_MA9)
M_A_A10: CN11.146(A10_AP) U1.BJ38(NC/DDR0_MA10)
M_A_A11: CN11.120(A11) U1.BB47(NC/DDR0_MA11)
M_A_A12: CN11.119(A12) U1.BE48(NC/DDR0_MA12)
M_A_A13: CN11.158(A13) U1.BM39(DDRB_CA0/DDR0_MA13)
M_A_ACT_N: CN11.114(ACT*) U1.BE49(N\C\/\D\D\R\0\_\A\C\T\_\N\)
M_A_BG0: CN11.115(BG0) U1.BB49(DDRA_CA5/DDR0_BG0)
M_A_BG1: CN11.113(BG1) U1.BD47(NC/DDR0_BG1)
M_A_BS0: CN11.150(BA0) U1.BM43(DDRB_CA4/DDR0_BA0)
M_A_BS1: CN11.145(BA1) U1.BG39(NC/DDR0_BA1)
M_A_CAS_N: CN11.156(A15_CAS*) U1.BJ42(DDRB_CA1/D\D\R\0\_\M\A\1\5\C\A\)
M_A_CB0: CN11.92(CB0_NC) R739.2
M_A_CB1: CN11.91(CB1_NC) R741.2
M_A_CB2: CN11.101(CB2_NC) R742.2
M_A_CB3: CN11.105(CB3_NC) R743.2
M_A_CB4: CN11.88(CB4_NC) R744.2
M_A_CB5: CN11.87(CB5_NC) R745.2
M_A_CB6: CN11.100(CB6_NC) R746.2
M_A_CB7: CN11.104(CB7_NC) R748.2
M_A_CKE<0>: CN11.109(CKE0) U1.BG49(DDRA_CKE0/DDR0_CKE0)
M_A_CKE<1>: CN11.110(CKE1) U1.BF41(DDRB_CKE1/DDR0_CKE1)
M_A_CLK_DDR_DN#<0>: CN11.139(CK0_C) U1.BL48(DDRA_CLK_N/DDR0_CLK_N_0)
M_A_CLK_DDR_DN#<1>: CN11.140(CK1_C) U1.BF42(DDRB_CLK_N/DDR0_CLK_N_1)
M_A_CLK_DDR_DP<0>: CN11.137(CK0_T) U1.BL47(DDRA_CLK_P/DDR0_CLK_P_0)
M_A_CLK_DDR_DP<1>: CN11.138(CK1_T) U1.BF43(DDRB_CLK_P/DDR0_CLK_P_1)
M_A_CS#<0>: CN11.149(S0*) U1.BM38(DDRA_CS_0/DDR0_CS_N_0)
M_A_CS#<1>: CN11.157(S1*) U1.BG42(DDRB_CS_1/DDR0_CS_N_1)
M_A_DQ<0>: CN11.45(DQ21) U1.CA48(DDRA_DQ0_0/DDR0_DQ0_0)
M_A_DQ<1>: CN11.49(DQ17) U1.CA47(DDRA_DQ0_1/DDR0_DQ0_1)
M_A_DQ<2>: CN11.50(DQ16) U1.CA49(DDRA_DQ0_2/DDR0_DQ0_2)
M_A_DQ<3>: CN11.59(DQ23) U1.BV49(DDRA_DQ0_3/DDR0_DQ0_3)
M_A_DQ<4>: CN11.46(DQ20) U1.CA45(DDRA_DQ0_4/DDR0_DQ0_4)
M_A_DQ<5>: CN11.62(DQ18) U1.BV47(DDRA_DQ0_5/DDR0_DQ0_5)
M_A_DQ<6>: CN11.58(DQ22) U1.BV45(DDRA_DQ0_6/DDR0_DQ0_6)
M_A_DQ<7>: CN11.63(DQ19) U1.BV48(DDRA_DQ0_7/DDR0_DQ0_7)
M_A_DQ<8>: CN11.16(DQ6) U1.CC42(DDRA_DQ1_0/DDR0_DQ1_0)
M_A_DQ<9>: CN11.20(DQ2) U1.CC39(DDRA_DQ1_1/DDR0_DQ1_1)
M_A_DQ<10>: CN11.17(DQ7) U1.CC43(DDRA_DQ1_2/DDR0_DQ1_2)
M_A_DQ<11>: CN11.4(DQ4) U1.CE38(DDRA_DQ1_3/DDR0_DQ1_3)
M_A_DQ<12>: CN11.21(DQ3) U1.CC38(DDRA_DQ1_4/DDR0_DQ1_4)
M_A_DQ<13>: CN11.3(DQ5) U1.CE39(DDRA_DQ1_5/DDR0_DQ1_5)
M_A_DQ<14>: CN11.7(DQ1) U1.CE42(DDRA_DQ1_6/DDR0_DQ1_6)
M_A_DQ<15>: CN11.8(DQ0) U1.CE43(DDRA_DQ1_7/DDR0_DQ1_7)
M_A_DQ<16>: CN11.70(DQ24) U1.BT48(DDRA_DQ2_0/DDR0_DQ2_0)
M_A_DQ<17>: CN11.67(DQ29) U1.BT47(DDRA_DQ2_1/DDR0_DQ2_1)
M_A_DQ<18>: CN11.66(DQ28) U1.BT49(DDRA_DQ2_2/DDR0_DQ2_2)
M_A_DQ<19>: CN11.79(DQ30) U1.BN49(DDRA_DQ2_3/DDR0_DQ2_3)
M_A_DQ<20>: CN11.80(DQ31) U1.BT45(DDRA_DQ2_4/DDR0_DQ2_4)
M_A_DQ<21>: CN11.71(DQ25) U1.BN47(DDRA_DQ2_5/DDR0_DQ2_5)
M_A_DQ<22>: CN11.84(DQ27) U1.BN45(DDRA_DQ2_6/DDR0_DQ2_6)
M_A_DQ<23>: CN11.83(DQ26) U1.BN48(DDRA_DQ2_7/DDR0_DQ2_7)
M_A_DQ<24>: CN11.41(DQ10) U1.BV42(DDRA_DQ3_0/DDR0_DQ3_0)
M_A_DQ<25>: CN11.38(DQ14) U1.BV39(DDRA_DQ3_1/DDR0_DQ3_1)
M_A_DQ<26>: CN11.37(DQ15) U1.BV43(DDRA_DQ3_2/DDR0_DQ3_2)
M_A_DQ<27>: CN11.24(DQ12) U1.BW38(DDRA_DQ3_3/DDR0_DQ3_3)
M_A_DQ<28>: CN11.42(DQ11) U1.BV38(DDRA_DQ3_4/DDR0_DQ3_4)
M_A_DQ<29>: CN11.25(DQ13) U1.BW39(DDRA_DQ3_5/DDR0_DQ3_5)
M_A_DQ<30>: CN11.28(DQ8) U1.BW42(DDRA_DQ3_6/DDR0_DQ3_6)
M_A_DQ<31>: CN11.29(DQ9) U1.BW43(DDRA_DQ3_7/DDR0_DQ3_7)
M_A_DQ<32>: CN11.170(DQ36) U1.AY48(DDRB_DQ0_0/DDR0_DQ4_0)
M_A_DQ<33>: CN11.187(DQ34) U1.AY47(DDRB_DQ0_1/DDR0_DQ4_1)
M_A_DQ<34>: CN11.174(DQ32) U1.AY49(DDRB_DQ0_2/DDR0_DQ4_2)
M_A_DQ<35>: CN11.173(DQ33) U1.AU45(DDRB_DQ0_3/DDR0_DQ4_3)
M_A_DQ<36>: CN11.169(DQ37) U1.AY45(DDRB_DQ0_4/DDR0_DQ4_4)
M_A_DQ<37>: CN11.186(DQ35) U1.AU47(DDRB_DQ0_5/DDR0_DQ4_5)
M_A_DQ<38>: CN11.182(DQ39) U1.AU48(DDRB_DQ0_6/DDR0_DQ4_6)
M_A_DQ<39>: CN11.183(DQ38) U1.AU49(DDRB_DQ0_7/DDR0_DQ4_7)
M_A_DQ<40>: CN11.229(DQ51) U1.AY42(DDRB_DQ1_0/DDR0_DQ5_0)
M_A_DQ<41>: CN11.224(DQ54) U1.AY38(DDRB_DQ1_1/DDR0_DQ5_1)
M_A_DQ<42>: CN11.225(DQ55) U1.AY43(DDRB_DQ1_2/DDR0_DQ5_2)
M_A_DQ<43>: CN11.212(DQ53) U1.BB39(DDRB_DQ1_3/DDR0_DQ5_3)
M_A_DQ<44>: CN11.228(DQ50) U1.AY39(DDRB_DQ1_4/DDR0_DQ5_4)
M_A_DQ<45>: CN11.216(DQ48) U1.BB38(DDRB_DQ1_5/DDR0_DQ5_5)
M_A_DQ<46>: CN11.215(DQ49) U1.BB42(DDRB_DQ1_6/DDR0_DQ5_6)
M_A_DQ<47>: CN11.211(DQ52) U1.BB43(DDRB_DQ1_7/DDR0_DQ5_7)
M_A_DQ<48>: CN11.191(DQ44) U1.AR48(DDRB_DQ2_0/DDR0_DQ6_0)
M_A_DQ<49>: CN11.195(DQ40) U1.AR47(DDRB_DQ2_1/DDR0_DQ6_1)
M_A_DQ<50>: CN11.194(DQ41) U1.AR49(DDRB_DQ2_2/DDR0_DQ6_2)
M_A_DQ<51>: CN11.207(DQ42) U1.AM45(DDRB_DQ2_3/DDR0_DQ6_3)
M_A_DQ<52>: CN11.190(DQ45) U1.AR45(DDRB_DQ2_4/DDR0_DQ6_4)
M_A_DQ<53>: CN11.203(DQ46) U1.AM47(DDRB_DQ2_5/DDR0_DQ6_5)
M_A_DQ<54>: CN11.208(DQ43) U1.AM48(DDRB_DQ2_6/DDR0_DQ6_6)
M_A_DQ<55>: CN11.204(DQ47) U1.AM49(DDRB_DQ2_7/DDR0_DQ6_7)
M_A_DQ<56>: CN11.236(DQ57) U1.AT42(DDRB_DQ3_0/DDR0_DQ7_0)
M_A_DQ<57>: CN11.233(DQ61) U1.AT39(DDRB_DQ3_1/DDR0_DQ7_1)
M_A_DQ<58>: CN11.245(DQ62) U1.AR43(DDRB_DQ3_2/DDR0_DQ7_2)
M_A_DQ<59>: CN11.237(DQ56) U1.AT38(DDRB_DQ3_3/DDR0_DQ7_3)
M_A_DQ<60>: CN11.249(DQ58) U1.AR38(DDRB_DQ3_4/DDR0_DQ7_4)
M_A_DQ<61>: CN11.246(DQ63) U1.AR39(DDRB_DQ3_5/DDR0_DQ7_5)
M_A_DQ<62>: CN11.250(DQ59) U1.AR42(DDRB_DQ3_6/DDR0_DQ7_6)
M_A_DQ<63>: CN11.232(DQ60) U1.AT43(DDRB_DQ3_7/DDR0_DQ7_7)
M_A_DQS_DN#<0>: CN11.53(DQS2_C) U1.BY47(DDRA_DQSN_0/DDR0_DQSN_0)
M_A_DQS_DN#<1>: CN11.11(DQS0_C) U1.CC41(DDRA_DQSN_1/DDR0_DQSN_1)
M_A_DQS_DN#<2>: CN11.74(DQS3_C) U1.BR47(DDRA_DQSN_2/DDR0_DQSN_2)
M_A_DQS_DN#<3>: CN11.32(DQS1_C) U1.BV41(DDRA_DQSN_3/DDR0_DQSN_3)
M_A_DQS_DN#<4>: CN11.177(DQS4_C) U1.AV46(DDRB_DQSN_0/DDR0_DQSN_4)
M_A_DQS_DN#<5>: CN11.219(DQS6_C) U1.AY41(DDRB_DQSN_1/DDR0_DQSN_5)
M_A_DQS_DN#<6>: CN11.198(DQS5_C) U1.AN46(DDRB_DQSN_2/DDR0_DQSN_6)
M_A_DQS_DN#<7>: CN11.240(DQS7_C) U1.AR41(DDRB_DQSN_3/DDR0_DQSN_7)
M_A_DQS_DP<0>: CN11.55(DQS2_T) U1.BY46(DDRA_DQSP_0/DDR0_DQSP_0)
M_A_DQS_DP<1>: CN11.13(DQS0_T) U1.CE41(DDRA_DQSP_1/DDR0_DQSP_1)
M_A_DQS_DP<2>: CN11.76(DQS3_T) U1.BR46(DDRA_DQSP_2/DDR0_DQSP_2)
M_A_DQS_DP<3>: CN11.34(DQS1_T) U1.BW41(DDRA_DQSP_3/DDR0_DQSP_3)
M_A_DQS_DP<4>: CN11.179(DQS4_T) U1.AV47(DDRB_DQSP_0/DDR0_DQSP_4)
M_A_DQS_DP<5>: CN11.221(DQS6_T) U1.BB41(DDRB_DQSP_1/DDR0_DQSP_5)
M_A_DQS_DP<6>: CN11.200(DQS5_T) U1.AN47(DDRB_DQSP_2/DDR0_DQSP_6)
M_A_DQS_DP<7>: CN11.242(DQS7_T) U1.AT41(DDRB_DQSP_3/DDR0_DQSP_7)
M_A_DRAMRST: C887.2 CN11.108(RESET*) R747.1 R749.2
M_A_ODT<0>: CN11.155(ODT0) U1.BJ39(NC/DDR0_ODT_0)
M_A_ODT<1>: CN11.161(ODT1) U1.BB45(NC/DDR0_ODT_1)
M_A_RAS_N: CN11.152(A16_RAS*) U1.BM41(DDRB_CA3/D\D\R\0\_\M\A\1\6\R\A\)
M_A_WE_N: CN11.151(A14_WE*) U1.BG43(DDRB_CA2/D\D\R\0\_\M\A\1\4\W\E\)
M_B_A0: CN19.144(A0) U1.P42(NC/DDR1_MA0)
M_B_A1: CN19.133(A1) U1.Y49(NC/DDR1_MA1)
M_B_A2: CN19.132(A2) U1.U48(DDRD_CA5/DDR1_MA2)
M_B_A3: CN19.131(A3) U1.Y45(NC/DDR1_MA3)
M_B_A4: CN19.128(A4) U1.U47(NC/DDR1_MA4)
M_B_A5: CN19.126(A5) U1.R49(DDRC_CA0/DDR1_MA5)
M_B_A6: CN19.127(A6) U1.U49(DDRC_CA2/DDR1_MA6)
M_B_A7: CN19.122(A7) U1.M47(DDRC_CA4/DDR1_MA7)
M_B_A8: CN19.125(A8) U1.M45(DDRC_CA3/DDR1_MA8)
M_B_A9: CN19.121(A9) U1.R47(DDRC_CA1/DDR1_MA9)
M_B_A10: CN19.146(A10_AP) U1.P39(NC/DDR1_MA10)
M_B_A11: CN19.120(A11) U1.N46(NC/DDR1_MA11)
M_B_A12: CN19.119(A12) U1.R48(NC/DDR1_MA12)
M_B_A13: CN19.158(A13) U1.Y41(DDRD_CA0/DDR1_MA13)
M_B_ACT_N: CN19.114(ACT*) U1.M48(NC/D\D\R\1\_\A\C\T\_\N\)
M_B_BG0: CN19.115(BG0) U1.R45(DDRC_CA5/DDR1_BG0)
M_B_BG1: CN19.113(BG1) U1.N47(NC/DDR1_BG1)
M_B_BS0: CN19.150(BA0) U1.T38(DDRD_CA4/DDR1_BA0)
M_B_BS1: CN19.145(BA1) U1.T42(NC/DDR1_BA1)
M_B_CAS_N: CN19.156(A15_CAS*) U1.Y42(DDRD_CA1/D\D\R\1\_\M\A\1\5\C\A\)
M_B_CB0: CN19.92(CB0_NC) R291.2
M_B_CB1: CN19.91(CB1_NC) R293.2
M_B_CB2: CN19.101(CB2_NC) R294.2
M_B_CB3: CN19.105(CB3_NC) R295.2
M_B_CB4: CN19.88(CB4_NC) R296.2
M_B_CB5: CN19.87(CB5_NC) R297.2
M_B_CB6: CN19.100(CB6_NC) R298.2
M_B_CB7: CN19.104(CB7_NC) R299.2
M_B_CKE<0>: CN19.109(CKE0) U1.U45(DDRC_CKE0/DDR1_CKE0)
M_B_CKE<1>: CN19.110(CKE1) U1.P43(DDRD_CKE1/DDR1_CKE1)
M_B_CLK_DDR_DN*<0>: CN19.139(CK0_C) U1.Y48(DDRC_CLK_N/DDR1_CLK_N_0)
M_B_CLK_DDR_DN*<1>: CN19.140(CK1_C) U1.M43(DDRD_CLK_N/DDR1_CLK_N_1)
M_B_CLK_DDR_DP<0>: CN19.137(CK0_T) U1.Y47(DDRC_CLK_P/DDR1_CLK_P_0)
M_B_CLK_DDR_DP<1>: CN19.138(CK1_T) U1.M42(DDRD_CLK_P/DDR1_CLK_P_1)
M_B_CS*<0>: CN19.149(S0*) U1.V42(DDRC_CS_0/DDR1_CS_N_0)
M_B_CS*<1>: CN19.157(S1*) U1.T39(DDRD_CS_1/DDR1_CS_N_1)
M_B_CSA1_N: CN19.162(S2*/C0) U1.V39(DDRC_CS_1/NC)
M_B_CSB0_N: CN19.165(S3*/C1) U1.Y39(DDRD_CS_0/NC)
M_B_DQ<0>: CN19.45(DQ21) U1.AK48(DDRC_DQ0_0/DDR1_DQ0_0)
M_B_DQ<1>: CN19.50(DQ16) U1.AK45(DDRC_DQ0_1/DDR1_DQ0_1)
M_B_DQ<2>: CN19.46(DQ20) U1.AK49(DDRC_DQ0_2/DDR1_DQ0_2)
M_B_DQ<3>: CN19.59(DQ23) U1.AG47(DDRC_DQ0_3/DDR1_DQ0_3)
M_B_DQ<4>: CN19.49(DQ17) U1.AK47(DDRC_DQ0_4/DDR1_DQ0_4)
M_B_DQ<5>: CN19.63(DQ19) U1.AG45(DDRC_DQ0_5/DDR1_DQ0_5)
M_B_DQ<6>: CN19.58(DQ22) U1.AG48(DDRC_DQ0_6/DDR1_DQ0_6)
M_B_DQ<7>: CN19.62(DQ18) U1.AG49(DDRC_DQ0_7/DDR1_DQ0_7)
M_B_DQ<8>: CN19.21(DQ3) U1.AJ38(DDRC_DQ1_0/DDR1_DQ1_0)
M_B_DQ<9>: CN19.8(DQ0) U1.AL39(DDRC_DQ1_1/DDR1_DQ1_1)
M_B_DQ<10>: CN19.16(DQ6) U1.AJ39(DDRC_DQ1_2/DDR1_DQ1_2)
M_B_DQ<11>: CN19.3(DQ5) U1.AL43(DDRC_DQ1_3/DDR1_DQ1_3)
M_B_DQ<12>: CN19.4(DQ4) U1.AL38(DDRC_DQ1_4/DDR1_DQ1_4)
M_B_DQ<13>: CN19.20(DQ2) U1.AJ42(DDRC_DQ1_5/DDR1_DQ1_5)
M_B_DQ<14>: CN19.7(DQ1) U1.AL42(DDRC_DQ1_6/DDR1_DQ1_6)
M_B_DQ<15>: CN19.17(DQ7) U1.AJ43(DDRC_DQ1_7/DDR1_DQ1_7)
M_B_DQ<16>: CN19.83(DQ26) U1.AB49(DDRC_DQ2_0/DDR1_DQ2_0)
M_B_DQ<17>: CN19.84(DQ27) U1.AB48(DDRC_DQ2_1/DDR1_DQ2_1)
M_B_DQ<18>: CN19.70(DQ24) U1.AE49(DDRC_DQ2_2/DDR1_DQ2_2)
M_B_DQ<19>: CN19.71(DQ25) U1.AE47(DDRC_DQ2_3/DDR1_DQ2_3)
M_B_DQ<20>: CN19.67(DQ29) U1.AE48(DDRC_DQ2_4/DDR1_DQ2_4)
M_B_DQ<21>: CN19.80(DQ31) U1.AB47(DDRC_DQ2_5/DDR1_DQ2_5)
M_B_DQ<22>: CN19.79(DQ30) U1.AB45(DDRC_DQ2_6/DDR1_DQ2_6)
M_B_DQ<23>: CN19.66(DQ28) U1.AE45(DDRC_DQ2_7/DDR1_DQ2_7)
M_B_DQ<24>: CN19.42(DQ11) U1.AD38(DDRC_DQ3_0/DDR1_DQ3_0)
M_B_DQ<25>: CN19.38(DQ14) U1.AD39(DDRC_DQ3_1/DDR1_DQ3_1)
M_B_DQ<26>: CN19.24(DQ12) U1.AE39(DDRC_DQ3_2/DDR1_DQ3_2)
M_B_DQ<27>: CN19.29(DQ9) U1.AE43(DDRC_DQ3_3/DDR1_DQ3_3)
M_B_DQ<28>: CN19.25(DQ13) U1.AE38(DDRC_DQ3_4/DDR1_DQ3_4)
M_B_DQ<29>: CN19.37(DQ15) U1.AD43(DDRC_DQ3_5/DDR1_DQ3_5)
M_B_DQ<30>: CN19.41(DQ10) U1.AD42(DDRC_DQ3_6/DDR1_DQ3_6)
M_B_DQ<31>: CN19.28(DQ8) U1.AE42(DDRC_DQ3_7/DDR1_DQ3_7)
M_B_DQ<32>: CN19.174(DQ32) U1.J48(DDRD_DQ0_0/DDR1_DQ4_0)
M_B_DQ<33>: CN19.170(DQ36) U1.J45(DDRD_DQ0_1/DDR1_DQ4_1)
M_B_DQ<34>: CN19.169(DQ37) U1.J49(DDRD_DQ0_2/DDR1_DQ4_2)
M_B_DQ<35>: CN19.182(DQ39) U1.G47(DDRD_DQ0_3/DDR1_DQ4_3)
M_B_DQ<36>: CN19.173(DQ33) U1.J47(DDRD_DQ0_4/DDR1_DQ4_4)
M_B_DQ<37>: CN19.187(DQ34) U1.G45(DDRD_DQ0_5/DDR1_DQ4_5)
M_B_DQ<38>: CN19.186(DQ35) U1.G48(DDRD_DQ0_6/DDR1_DQ4_6)
M_B_DQ<39>: CN19.183(DQ38) U1.E48(DDRD_DQ0_7/DDR1_DQ4_7)
M_B_DQ<40>: CN19.194(DQ41) U1.J38(DDRD_DQ1_0/DDR1_DQ5_0)
M_B_DQ<41>: CN19.203(DQ46) U1.G39(DDRD_DQ1_1/DDR1_DQ5_1)
M_B_DQ<42>: CN19.207(DQ42) U1.G38(DDRD_DQ1_2/DDR1_DQ5_2)
M_B_DQ<43>: CN19.208(DQ43) U1.G42(DDRD_DQ1_3/DDR1_DQ5_3)
M_B_DQ<44>: CN19.190(DQ45) U1.J39(DDRD_DQ1_4/DDR1_DQ5_4)
M_B_DQ<45>: CN19.191(DQ44) U1.J42(DDRD_DQ1_5/DDR1_DQ5_5)
M_B_DQ<46>: CN19.204(DQ47) U1.G43(DDRD_DQ1_6/DDR1_DQ5_6)
M_B_DQ<47>: CN19.195(DQ40) U1.J43(DDRD_DQ1_7/DDR1_DQ5_7)
M_B_DQ<48>: CN19.215(DQ49) U1.B43(DDRD_DQ2_0/DDR1_DQ6_0)
M_B_DQ<49>: CN19.229(DQ51) U1.D43(DDRD_DQ2_1/DDR1_DQ6_1)
M_B_DQ<50>: CN19.211(DQ52) U1.A43(DDRD_DQ2_2/DDR1_DQ6_2)
M_B_DQ<51>: CN19.228(DQ50) U1.C40(DDRD_DQ2_3/DDR1_DQ6_3)
M_B_DQ<52>: CN19.216(DQ48) U1.C43(DDRD_DQ2_4/DDR1_DQ6_4)
M_B_DQ<53>: CN19.212(DQ53) U1.D40(DDRD_DQ2_5/DDR1_DQ6_5)
M_B_DQ<54>: CN19.224(DQ54) U1.B40(DDRD_DQ2_6/DDR1_DQ6_6)
M_B_DQ<55>: CN19.225(DQ55) U1.A40(DDRD_DQ2_7/DDR1_DQ6_7)
M_B_DQ<56>: CN19.233(DQ61) U1.B35(DDRD_DQ3_0/DDR1_DQ7_0)
M_B_DQ<57>: CN19.246(DQ63) U1.D35(DDRD_DQ3_1/DDR1_DQ7_1)
M_B_DQ<58>: CN19.237(DQ56) U1.A35(DDRD_DQ3_2/DDR1_DQ7_2)
M_B_DQ<59>: CN19.236(DQ57) U1.D38(DDRD_DQ3_3/DDR1_DQ7_3)
M_B_DQ<60>: CN19.232(DQ60) U1.C35(DDRD_DQ3_4/DDR1_DQ7_4)
M_B_DQ<61>: CN19.249(DQ58) U1.C38(DDRD_DQ3_5/DDR1_DQ7_5)
M_B_DQ<62>: CN19.245(DQ62) U1.B38(DDRD_DQ3_6/DDR1_DQ7_6)
M_B_DQ<63>: CN19.250(DQ59) U1.A38(DDRD_DQ3_7/DDR1_DQ7_7)
M_B_DQS_DN*<0>: CN19.53(DQS2_C) U1.AH46(DDRC_DQSN_0/DDR1_DQSN_0)
M_B_DQS_DN*<1>: CN19.11(DQS0_C) U1.AJ41(DDRC_DQSN_1/DDR1_DQSN_1)
M_B_DQS_DN*<2>: CN19.74(DQS3_C) U1.AC47(DDRC_DQSN_2/DDR1_DQSN_2)
M_B_DQS_DN*<3>: CN19.32(DQS1_C) U1.AE41(DDRC_DQSN_3/DDR1_DQSN_3)
M_B_DQS_DN*<4>: CN19.177(DQS4_C) U1.H47(DDRD_DQSN_0/DDR1_DQSN_4)
M_B_DQS_DN*<5>: CN19.198(DQS5_C) U1.G41(DDRD_DQSN_1/DDR1_DQSN_5)
M_B_DQS_DN*<6>: CN19.219(DQS6_C) U1.C42(DDRD_DQSN_2/DDR1_DQSN_6)
M_B_DQS_DN*<7>: CN19.240(DQS7_C) U1.D36(DDRD_DQSN_3/DDR1_DQSN_7)
M_B_DQS_DP<0>: CN19.55(DQS2_T) U1.AH47(DDRC_DQSP_0/DDR1_DQSP_0)
M_B_DQS_DP<1>: CN19.13(DQS0_T) U1.AL41(DDRC_DQSP_1/DDR1_DQSP_1)
M_B_DQS_DP<2>: CN19.76(DQS3_T) U1.AC46(DDRC_DQSP_2/DDR1_DQSP_2)
M_B_DQS_DP<3>: CN19.34(DQS1_T) U1.AD41(DDRC_DQSP_3/DDR1_DQSP_3)
M_B_DQS_DP<4>: CN19.179(DQS4_T) U1.H46(DDRD_DQSP_0/DDR1_DQSP_4)
M_B_DQS_DP<5>: CN19.200(DQS5_T) U1.J41(DDRD_DQSP_1/DDR1_DQSP_5)
M_B_DQS_DP<6>: CN19.221(DQS6_T) U1.D42(DDRD_DQSP_2/DDR1_DQSP_6)
M_B_DQS_DP<7>: CN19.242(DQS7_T) U1.C36(DDRD_DQSP_3/DDR1_DQSP_7)
M_B_DRAMRST: C157.2 CN19.108(RESET*) R300.1 R301.2
M_B_ODT<0>: CN19.155(ODT0) U1.V43(NC/DDR1_ODT_0)
M_B_ODT<1>: CN19.161(ODT1) U1.V38(NC/DDR1_ODT_1)
M_B_RAS_N: CN19.152(A16_RAS*) U1.V47(DDRD_CA3/D\D\R\1\_\M\A\1\6\R\A\)
M_B_WE_N: CN19.151(A14_WE*) U1.V41(DDRD_CA2/D\D\R\1\_\M\A\1\4\W\E\)
MDI0+: U30.1(MDIP0) U31.2(TD1+)
MDI0-: U30.2(MDIN0) U31.3(TD1-)
MDI1+: U30.4(MDIP1) U31.5(TD2+)
MDI1-: U30.5(MDIN1) U31.6(TD2-)
MDI2+: U30.6(MDIP2) U31.8(TD3+)
MDI2-: U30.7(MDIN2) U31.9(TD3-)
MDI3+: U30.9(MDIP3) U31.11(TD4+)
MDI3-: U30.10(MDIN3) U31.12(TD4-)
ME_FLASH: R165.2 R629.2 U9.109(LID_SW#/GPB1)
MFR_MODE_DET_STRAP: R160.1 R162.2 U1.DU33(GPP_D16/ISH_UART0_CTS_N/CNV_WCE)
MIC2-VREFO: D64.P U25.29(MIC2-VREFO)
OPTION1_GPU: R62.2 U9.123(CTX0/TMA0/GPB2)
OPTION2_GPU: R511.2 U9.99(GPH6/ID6)
OUT_CLK+: C373.2 FIL8.4(GND) R202.2 R456.1
OUT_CLK-: C374.2 FIL8.1(UNB) R201.2 R457.1
OUT_D0+: C371.2 FIL7.4(GND) R251.2 R454.1
OUT_D0-: C372.2 FIL7.1(UNB) R249.2 R455.1
OUT_D1+: C369.2 FIL6.4(GND) R254.2 R452.1
OUT_D1-: C370.2 FIL6.1(UNB) R253.2 R453.1
OUT_D2+: C367.2 FIL5.4(GND) R257.2 R450.1
OUT_D2-: C368.2 FIL5.1(UNB) R255.2 R451.1
OVERT: CN14.46(LED_WPAN#) R15.2
OVPA: R520.2 R521.2 R534.1 R536.2 U37.7(OVP)
PCBBEEP: C478.2 C479.1 R395.1
PCH_GPU_RST1: R72.1 U1.DV33(GPP_D13/ISH_UART0_RXD) U32.1(A)
PCH_IST_TP_0: TP22.1 U1.CW33(PCH_IST_TP_0)
PCH_IST_TP_1: TP23.1 U1.CY32(PCH_IST_TP_1)
PCH_NVME_RST: R526.2 U1.DU36(GPP_D0/ISH_GP0)
PCH_PLT_RST#: R830.1 U1.CM49(GPP_B13/P\L\T\R\S\T\_\N\) U5.1(A) U5.2(B)
PCH_POPIRCOMP: R85.1 U1.DU3(PCH_OPIRCOMP)
PCH_PWROK: R94.1 R323.2 U1.DN47(PCH_PWROK) U9.35(RTS1#/GPE5)
PCH_SLP_LAN#: R387.1 TP7.1 U1.DN48(S\L\P\_\L\A\N\_\N\)
PCH_SLP_S5#: R1389.1 U1.DF45(GPD10/S\L\P\_\S\5\_\N\)
PCH_SLP_SA#: R383.1 U1.DH47(GPD6/S\L\P\_\A\_\N\)
PCH_SLP_WLAN#: R384.1 TP8.1 U1.DE49(GPD9/S\P\L\_\W\L\A\N\_\N\)
PCH_SYSRST#: C6140.2 R79.2 R92.2 U1.DK19(S\Y\S\_\R\E\S\E\T\_\N\)
PCIE_GPU_WAKE#: D38.P R439.2 R441.2
PCIE_RCOMPN: R67.2 U1.DN1(PCIE_RCOMPN)
PCIE_RCOMPP: R67.1 U1.DN3(PCIE_RCOMPP)
PCIE_RX_DN<10>: C422.1 U1.CE6(PCIE14_RXN)
PCIE_RX_DN_5_GPU: CN14.44(LED_WLAN#) U1.DA6(PCIE5_RXN/USB31_5_RXN)
PCIE_RX_DN_6_GPU: CN14.38(USB_D+) U1.CY7(PCIE6_RXN/USB31_6_RXN)
PCIE_RX_DN_7_GPU: CN14.51(RSVD12) U1.CV7(PCIE7_RXN)
PCIE_RX_DN_8_GPU: CN14.45(C_CLK) U1.CT6(PCIE8_RXN)
PCIE_RX_DN_9_WIFI: CN22.43(PERN0) U1.CG7(PCIE13_RXN)
PCIE_RX_DN_13_SSD: CN10.5(PERN3) U1.CP7(PCIE9_RXN)
PCIE_RX_DN_14_SSD: CN10.17(PERN2) U1.CM7(PCIE10_RXN)
PCIE_RX_DN_15_SSD: CN10.29(PERN1) U1.CK7(PCIE11_RXN/SATA0_RXN)
PCIE_RX_DN_16_SSD: R337.1 U1.CJ6(PCIE12_RXN/SATA1A_RXN)
PCIE_RX_DP<10>: C423.1 U1.CE7(PCIE14_RXP)
PCIE_RX_DP_5_GPU: CN14.42(LED_WWAN#) U1.DA7(PCIE5_RXP/USB31_5_RXP)
PCIE_RX_DP_6_GPU: CN14.36(USB_D-) U1.CY6(PCIE6_RXP/USB31_6_RXP)
PCIE_RX_DP_7_GPU: CN14.49(C_RST) U1.CV6(PCIE7_RXP)
PCIE_RX_DP_8_GPU: CN14.43(RSVD8) U1.CT7(PCIE8_RXP)
PCIE_RX_DP_9_WIFI: CN22.41(PERP0) U1.CG6(PCIE13_RXP)
PCIE_RX_DP_13_SSD: CN10.7(PERP3) U1.CP6(PCIE9_RXP)
PCIE_RX_DP_14_SSD: CN10.19(PERP2) U1.CM6(PCIE10_RXP)
PCIE_RX_DP_15_SSD: CN10.31(PERP1) U1.CK6(PCIE11_RXP/SATA0_RXP)
PCIE_RX_DP_16_SSD: R331.1 U1.CJ7(PCIE12_RXP/SATA1A_RXP)
PCIE_TX_DN<10>: C71.2 U30.14(HSIN)
PCIE_TX_DN_5_GPU: C3.2 CN14.39(RSVD6)
PCIE_TX_DN_6_GPU: C60.2 CN14.33(PET_P0)
PCIE_TX_DN_7_GPU: C62.2 CN14.25(PER_P0)
PCIE_TX_DN_8_GPU: C67.2 CN14.19(RSVD4)
PCIE_TX_DN_9_WIFI: C64.2 CN22.37(PETN0)
PCIE_TX_DN_13_SSD: C73.2 CN10.11(PETN3)
PCIE_TX_DN_14_SSD: C77.2 CN10.23(PETN2)
PCIE_TX_DN_15_SSD: C79.2 CN10.35(PETN1)
PCIE_TX_DN_16_SSD: C277.2 U1.CW5(PCIE12_TXN/SATA1A_TXN)
PCIE_TX_DP<10>: C72.2 U30.13(HSIP)
PCIE_TX_DP_5_GPU: C12.2 CN14.37(RSVD5)
PCIE_TX_DP_6_GPU: C61.2 CN14.31(PET_N0)
PCIE_TX_DP_7_GPU: C66.2 CN14.23(PER_N0)
PCIE_TX_DP_8_GPU: C133.2 CN14.17(RSVD3)
PCIE_TX_DP_9_WIFI: C65.2 CN22.35(PETP0)
PCIE_TX_DP_13_SSD: C74.2 CN10.13(PETP3)
PCIE_TX_DP_14_SSD: C78.2 CN10.25(PETP2)
PCIE_TX_DP_15_SSD: C81.2 CN10.37(PETP1)
PCIE_TX_DP_16_SSD: C278.2 U1.CW3(PCIE12_TXP/SATA1A_TXP)
PD#: U23.4(Y) U25.47(PDB)
PECIRQT#: R1400.2 U9.118(SMDAT2/PECIRQT#/GPF7)
PEDET: CN10.69(PEDET (NC-PCIE/GND-SATA)) Q40.1(G) R273.1 R338.1 R535.1
PEX_RST: CN14.22(PERST#) R515.2 R518.1 U33.4(Y)
PHASE1: LPM1.1 PC11.1 PR5.1 PR14.2 PR25.2 Q5.1(S1) Q5.2(S2) Q5.3(S3) Q6.5(D1) Q6.6(D2) Q6.7(D3) Q6.8(D4) U3.34(PHASE1)
PHASE2: LPM2.1 PC10.1 PR44.1 PR47.2 PR49.2 Q8.1(S1) Q8.2(S2) Q8.3(S3) Q9.5(D1) Q9.6(D2) Q9.7(D3) Q9.8(D4) U3.38(PHASE2)
PHASE3: LPM3.1 PC12.2 PR67.1 PR73.2 PR79.2 PU3.2(PHASE) Q29.1(S1) Q29.2(S2) Q29.3(S3) Q32.5(D1) Q32.6(D2) Q32.7(D3) Q32.8(D4)
PLT_RST_BUF#: R168.1 R244.1 R358.2 R514.1 R525.1 R1397.2 U5.4(Y) U10.1(A) U18.1(A) U32.2(B) U40.1(A) U57.1(A) U57.2(B)
PLTRST_PEG_SLOTS_N: DR1.2 R513.1 R515.1 U33.1(A)
PM_BATLOW#: R69.2 U1.DH48(GPD0/B\A\T\L\O\W\_\N\) U9.21(RI2#/GPD1)
PM_CPUPWRGD: TP6.1 U1.CF1(PROCPWRGD)
PM_EC_PWRBTN#: R28.2 U1.CY42(GPD3/P\W\R\B\T\N\_\N\) U9.19(SMCLK4/L80HLAT/BAO/GPE0)
PM_LANPHY_ENABLE: TP10.1 U1.DF48(GPD11/LANPHYPC/DSWLDO_MON)
PM_RSMRST#: R108.1 U1.DG49(R\S\M\R\S\T\_\N\) U9.93(CLKRUN#/GPH0/ID0)
PM_SLP_S0#: R68.2 R353.1 R412.2 U9.128(GPJ6)
PM_SLP_S3#: D71.P Q79.1(G) R83.2 R117.1 R118.1 R381.1 R790.1 U2.7(S3) U9.80(DAC4/DCD0#/GPJ4) U54.2(B) U55.3(ON)
PM_SLP_S4#: D70.P Q77.1(G) R103.2 R112.1 R185.2 R382.1 U9.79(DAC3/TACH1B/GPJ3)
PM_SLP_SUS#: Q76.1(G) R101.1 R377.1 R792.2 R896.1 R897.1 U9.17(TXD/SOUT0/LPCPD#GPE6)
POWSW#: C3218.2 C6064.1 D19.N D20.N D58.1 R174.1 SW1.1
PROCHOT#_EC: R325.2 R548.2 U9.20(SMDAT4/L80LLAT/GPE7) U34.2(A)
PRSNT_R#: CN14.48(+1.5V_3) R511.1
PS_LATCH#: D19.P D72.P Q30.1(G) Q31.3(D) R172.2
PS_S3CNTRL: Q4.1(G) Q69.1(G) Q71.3(D) R203.2 R788.2
PWM: R522.2 R527.1 R529.2 R530.2 R532.2 U37.16(PWM)
PWR_LED_BLUE: Q36.1(IN) U9.95(CTX1/SOUT1/GPH2/SMDAT3/ID2)
PWRONLATCHG: C228.2 C229.1 Q17.4(G) R170.1 R172.1
R_OUT+: C6123.1 CN8.2 D62.N R268.2
R_OUT-: C6124.1 CN8.1 D61.N R267.2
REGOUT: L8.1 R363.1 U30.24(REGOUT)
REXT: R608.2 U42.26(REXT)
RLV_AMP: R607.2 U42.27(RLV_AMP)
RLV_CFG: R603.1 R604.2 U42.22(RLV_CFG)
RLV_LNK: R597.1 R598.2 U42.21(RLV_LNK/GPIO0) U44.7(WP/WC#)
ROP_VCCST_PWRGD: Q13.1(G) R116.2 R119.1 U9.85(PS2CLK0/TMB0/CEC/GPF0)
RSET: R493.2 U30.31(RSET)
RT3614_DRVEN: PR11.1 PR93.2 U3.2(DRVEN)
RT3614_ISEN1N: R781.1 U3.23(ISEN1N)
RT3614_ISEN1P: PC8.2 PR28.2 PR31.2 U3.24(ISEN1P)
RT3614_ISEN2N: R784.1 U3.22(ISEN2N)
RT3614_ISEN2P: PC21.2 PR45.2 PR54.2 U3.21(ISEN2P)
RT3614_ISEN3N: R785.1 U3.26(ISEN3N)
RT3614_ISEN3P: PC39.2 PR2.1 PR46.2 U3.25(ISEN3P)
RT3614_PWM3: PU3.5(PWM) U3.31(PWM3)
RT6543_ISEN1N: PR117.1 U6.3(ISENSEN)
RT6543_ISEN1P: PR116.1 U6.2(ISENSEP)
RT6543A_LG: PR40.1 U6.13(LGATE)
RT6543A_PHASE: LPM5.1 PC50.2 PR38.1 PR39.2 PR58.2 Q22.1(S1) Q22.2(S2) Q22.3(S3) Q23.5(D1) Q23.6(D2) Q23.7(D3) Q23.8(D4) U6.12(PH)
RT6543A_UG: PR36.1 U6.11(UGATE)
RT6543A_VSEN: PR61.2 PR62.2 PR64.2 PR108.2 U6.8(VOUT)
RTA: R556.2 U37.8(RT)
RTC_RESET: Q7.1(G) Q10.1(G) R335.2 U9.122(DTR1#/SBUSY/GPG1/ID7)
RTC_RST#: C14.1 PR13.1 R25.1 U1.DT47(R\T\C\R\S\T\_\N\)
RTC_X1: C47.1 R21.2 U1.DL48(RTCX1) X4.2(B)
RTC_X2: C46.1 R21.1 U1.DL49(RTCX2) X4.1(A)
S3_DISCHARGE: Q79.3(D) Q80.1(G) Q81.1(G) Q83.1(G) Q84.1(G) Q85.1(G) R795.1 R803.2
S4_DISCHARGE: Q77.3(D) Q78.1(G) R793.1 R802.2
SA0_DIM0: CN11.256(SA0) R738.1 R740.1
SA0_DIM1: CN19.256(SA0) R290.1 R292.1
SA1_DIM0: CN11.260(SA1) R735.1 R737.1
SA1_DIM1: CN19.260(SA1) R241.1 R289.1
SATA_RXN1_C: C453.2 CN9.S5
SATA_RXP1_C: C454.2 CN9.S6
SATA_TXN1_C: C452.2 CN9.S3
SATA_TXP1_C: C451.2 CN9.S2
SCL_CONN: CN3.15 D16.3(D3) Q1.3(D) R444.2
SD3_RCOMP: R279.2 U1.CJ43(SD3_RCOMP)
SD_RCOMP: R282.2 U1.CV38(SNDW_RCOMP)
SDA_CONN: CN3.16 D4.3(D3) Q2.3(D) R445.2
SLPS3#_CONTROL: Q69.3(D) R196.2 R465.2 R789.2
SM_INTRUDER#: R71.1 R839.1 U1.DR47(I\N\T\R\U\D\E\R\_\N\)
SMB_CLK: Q19.3(D) R632.2 U1.DK27(GPP_C0/SMBCLK)
SMB_CLK_S2: CN11.253(SCL) CN19.253(SCL) CN22.60(I2C CLK (O)(0/3.3)) Q19.2(S) R635.1
SMB_DATA: Q27.3(D) R633.2 U1.DP24(GPP_C1/SMBDATA)
SMB_DATA_S2: CN11.254(SDA) CN19.254(SDA) CN22.58(I2C DATA (IO)(0/3.3)) Q27.2(S) R634.1
SMB_L1CLK_PCH: R126.1 R647.2 U1.DN22(GPP_C6/SML1CLK/SUSWARN_N/SUSPWR)
SMB_L1DATA_PCH: R130.1 R648.2 U1.DL22(GPP_C7/SML1DATA/S\U\S\A\C\K\_\N)
SMBL0CLK_NFC: R637.2 U1.DK24(GPP_C3/SML0CLK)
SMBL0DATA_NFC: R636.2 U1.DJ24(GPP_C4/SML0DATA)
SMC_ONOFF#: D20.P R835.2 U9.110(PWRSW/GPB3)
SMC_RUNTIME_SCI#: R97.2 U1.DE47(GPD_2/L\A\N\_\W\A\K\E\_\N\) U9.23(ECSCI#/GPD3)
SMC_SHUTDOWN#: Q31.1(G) R811.2 U9.98(GPH5/ID5)
SOC_CATERR#: R129.2 U1.J4(C\A\T\E\R\R\_\N\) U13.2(A)
SOC_THRMTRIP#: R124.2 U1.E3(T\H\R\M\T\R\I\P\_\N\)
SPI_HOLD: R722.2 R726.2 U49.7(IO3/HOLD*) U49_1.7(HOLD#)
SPI_SCK_R: R724.2 U49.6(CLK) U49_1.6(SCK)
SPI_SI_R: R728.2 U49.5(DI/IO0) U49_1.5(DIO)
SPI_SO_R: R727.2 U49.2(DO/IO1) U49_1.2(DO)
SPI_WP_R: R723.2 R725.2 U49.3(IO2/WP*) U49_1.3(WP#)
SPK_L+: R265.1 U25.42(SPK-L+)
SPK_L-: R262.1 U25.43(SPK-L-)
SPK_R+: R268.1 U25.45(SPK-R+)
SPK_R-: R267.1 U25.44(SPK-R-)
SRTCRST#: C15.1 PR71.1 R27.1 U1.DK46(S\R\T\C\R\S\T\_\N\)
SSD_CLK_REQ#: CN10.52(CLKREQ# (I/O)(0/3.3V) OR N/C) R30.2 U1.DK33(G\P\P\_\D\5\/\S\R\C\C\L\K\R\E\Q)
SSD_PCIE_CLK_DN: CN10.53(REFCLKN) U1.CJ3(CLKOUT_PCIE_N0)
SSD_PCIE_CLK_DP: CN10.55(REFCLKP) U1.CJ5(CLKOUT_PCIE_P0)
SSD_PCIE_WAKE#: CN10.54(PEWAKE# (I/O)(0/3.3V) OR N/C) R223.2
SSD_PEDET: R364.1 U1.CR42(GPP_A12/SATAXPCIE1/SATAGP1)
SSD_SATA_DEVSLP: R901.1 U1.DU11(GPP_E5/DEVSLP1)
SSD_SATA_RXN1: C453.1 U1.CA6(PCIE16_RXN/SATA2_RXN)
SSD_SATA_RXP1: C454.1 U1.CA5(PCIE16_RXP/SATA2_RXP)
SSD_SATA_TXN1: C452.1 U1.CP1(PCIE16_TXN/SATA2_TXN)
SSD_SATA_TXP1: C451.1 U1.CP2(PCIE16_TXP/SATA2_TXP)
SSTCMP: R533.1 U37.15(SSTCMP)
STATUS: R537.1 U37.14(STATUS)
SUS_CK: CN10.68(SUSCLK(32KHZ) (O)(0/3.3V)) R19.2 R275.1 R911.2 U1.DF49(GPD8/SUSCLK)
SYNC: R277.2 R627.2 U1.CV49(GPP_R1/HDA_SYNC/I2S0_SFRM)
SYS_PWROK: R110.1 U1.DP19(SYS_PWROK) U9.126(GA20/GPB5)
TBCLK: R138.2 R1399.1 U9.89(PS2CLK2/GPF4)
TBDATA: R140.2 U9.90(PS2DAT2/GPF5)
TCRCOMP_DN: R18.1 U1.AY1(TC_RCOMP_N)
TCRCOMP_DP: R18.2 U1.AY2(TC_RCOMP_P)
TLS_CONFIDENTIALITY: R179.1 R180.2 U1.DL24(GPP_C2/S\M\B\A\L\E\R\T\_\N\)
TMDS_CLKN: C374.1 U1.AC1(DDIB_TXN_3)
TMDS_CLKP: C373.1 U1.AC2(DDIB_TXP_3)
TMDS_DATAN0: C372.1 U1.AC5(DDIB_TXN_2)
TMDS_DATAN1: C370.1 U1.AE2(DDIB_TXN_1)
TMDS_DATAN2: C368.1 U1.AE3(DDIB_TXN_0)
TMDS_DATAP0: C371.1 U1.AC3(DDIB_TXP_2)
TMDS_DATAP1: C369.1 U1.AE1(DDIB_TXP_1)
TMDS_DATAP2: C367.1 U1.AE5(DDIB_TXP_0)
TP_CM33: TP19.1 U1.CM33(TP_3)
TP_DB10: TP20.1 U1.DB10(TP_4)
TP_DH49: TP25.1(TP) U1.DH49(RSVD_TP_9)
TP_DV47: TP21.1(TP) U1.DV47(TP_2)
TP_DW47: TP24.1(TP) U1.DW47(TP_1)
TP_LTB_CFG_STB1_DP: TP47.1 U1.Y7(CFG_19)
TP_MBP1_N: TP53.1 U1.T7(BPM_N_1)
TP_MBP2_N: TP54.1 U1.T10(BPM_N_2)
TP_MBP3_N: TP55.1 U1.T6(BPM_N_3)
TXN0_LVDS: C152.1 U42.5(DRX0N)
TXN1_LVDS: C154.1 U42.8(DRX1N)
TXP0_LVDS: C153.1 U42.4(DRX0P)
TXP1_LVDS: C155.1 U42.7(DRX1P)
UART1_RXD: J9.2 R653.1 TP49.1 U1.DW22(GPP_C21/UART2_TXD)
UART1_TXD: J9.1 R654.1 TP48.1 U1.DT22(GPP_C20/UART2_RXD)
UGATE1: PR1.1 U3.33(UGATE1)
UGATE2: PR43.1 U3.39(UGATE2)
UGATE3: PR65.1 PU3.3(UGATE)
USB2_COMP: R612.2 U1.DN5(USB2_COMP)
USB2_DN0_CAM: CN12.2 D33.N FIL13.4(GND) R315.2
USB2_DN<1>: FIL1.4(GND) R424.1 U1.DN8(USB2N_1)
USB2_DN<3>: CN22.5(USB_D-) U1.DP13(USB2N_3)
USB2_DN<4>: FIL4.1(UNB) R448.1 U1.DK10(USB2N_4)
USB2_DN<5>: FIL13.3(DUMMY3) R315.1 U1.DL5(USB2N_5)
USB2_DN<7>: FIL9.4(GND) R477.1 U1.DK13(USB2N_7)
USB2_DN<9>: FIL14.1(UNB) R491.1 U1.DL2(USB2N_9)
USB2_DP0_CAM: CN12.3 D32.N FIL13.1(UNB) R489.2
USB2_DP<1>: FIL1.1(UNB) R427.1 U1.DP8(USB2P_1)
USB2_DP<3>: CN22.3(USB_D+) U1.DN13(USB2P_3)
USB2_DP<4>: FIL4.4(GND) R314.1 U1.DJ10(USB2P_4)
USB2_DP<5>: FIL13.2(DUMMY2) R489.1 U1.DL3(USB2P_5)
USB2_DP<7>: FIL9.1(UNB) R479.1 U1.DJ13(USB2P_7)
USB2_DP<9>: FIL14.4(GND) R488.1 U1.DL1(USB2P_9)
USB2_ID: R7.1 U1.DL6(USB_ID)
USB2_OC<0>: C6147.1 R609.2 R916.1 R917.2 U1.DW14(GPP_E9/U\S\B\_\O\C\0\_\N\) U11.3(OCB)
USB2_OC<1>: C6148.1 R610.2 R919.1 R920.2 U1.CR41(GPP_A14/USB_OC1_N/DDSP_HPD3/DIS) U22.3(OCB)
USB2_OC<2>: C6154.1 C6156.1 R925.1 R926.2 R927.2 R931.1 R932.2 U1.CT41(GPP_A15/USB_OC2_N/DDSP_HPD4/DIS) U27.3(OCB) U41.3(OCB)
USB2_OC<3>: C6155.1 R928.2 R929.1 R930.2 U1.CT43(GPP_A16/U\S\B\_\O\C\3\_\N\) U29.3(OCB)
USB2_P1_PWREN: R449.2 R485.1 R490.2 R492.1 U9.82(EGAD/GPE1) U27.4(EN) U29.4(EN)
USB2_VBUSSENSE: R73.1 U1.DL11(USB_VBUSSENSE)
USB3_P1_PWREN: R232.1 R918.2 U9.5(ALERT#/SERIRQ/GPM6) U11.4(EN)
USB3_P2_PWREN: R478.2 R482.1 U9.108(AC_IN#/GPB0) U22.4(EN)
USB3_RX_DN<1>: FIL2.4(GND) R428.1 U1.DJ8(PCIE1_RXN/USB31_1_RXN)
USB3_RX_DN<1>_C: D45.1(I/O1) D45.10(NC1) FIL2.3(DUMMY3) J1.5(STDA_SSRX-) R428.2
USB3_RX_DN<2>: FIL10.4(GND) R480.1 U1.DG9(PCIE2_RXN/USB31_2_RXN)
USB3_RX_DN<2>_C: D29.1(I/O1) D29.10(NC1) FIL10.3(DUMMY3) J2.5(STDA_SSRX-) R480.2
USB3_RX_DP<1>: FIL2.1(UNB) R429.1 U1.DJ6(PCIE1_RXP/USB31_1_RXP)
USB3_RX_DP<1>_C: D45.2(I/O2) D45.9(NC2) FIL2.2(DUMMY2) J1.6(STDA_SSRX+) R429.2
USB3_RX_DP<2>: FIL10.1(UNB) R481.1 U1.DG7(PCIE2_RXP/USB31_2_RXP)
USB3_RX_DP<2>_C: D29.2(I/O2) D29.9(NC2) FIL10.2(DUMMY2) J2.6(STDA_SSRX+) R481.2
USB3_TX_DN<1>: C233.2 U1.DJ2(PCIE1_TXN/USB31_1_TXN)
USB3_TX_DN<1>_C: D45.4(I/O3) D45.7(NC3) FIL3.3(DUMMY3) J1.8(STDA_SSTX-) R430.2
USB3_TX_DN<2>: C386.2 U1.DJ3(PCIE2_TXN/USB31_2_TXN)
USB3_TX_DN<2>_C: D29.4(I/O3) D29.7(NC3) FIL11.3(DUMMY3) J2.8(STDA_SSTX-) R483.2
USB3_TX_DP<1>: C234.2 U1.DJ1(PCIE1_TXP/USB31_1_TXP)
USB3_TX_DP<1>_C: D45.5(I/O4) D45.6(NC4) FIL3.2(DUMMY2) J1.9(STDA_SSTX+) R431.2
USB3_TX_DP<2>: C387.2 U1.DJ5(PCIE2_TXP/USB31_2_TXP)
USB3_TX_DP<2>_C: D29.5(I/O4) D29.6(NC4) FIL11.2(DUMMY2) J2.9(STDA_SSTX+) R484.2
VCLK: C23.1 C24.1 U7.12(ILMT/CLK)
VNN_BYPASS: R99.2 U1.CY34(VCC_VNNEXT_1P05)
VR_ALERT#: R242.1 U3.5(ALERT)
VR_VCLK: R235.1 U3.7(VCLK)
VR_VDIO: R239.1 U3.6(VDIO)
VREF: PR7.2 PR8.2 PR9.2 PR81.2 PR94.2 PR100.2 PR103.2 U3.14(VREF06)
VREF_CA: C885.2 C886.2 CN11.164(VREFCA) R128.1 R167.1 R730.2 R732.1
VREFA: C512.2 R537.2 U37.12(VREF)
VRHOT: R259.1 U3.4(VRHOT)
VSPI: R48.2 U9.106(VFSPI)
WIFI_CLK_REQ#: R16.2 R145.2 U1.DN34(GPP_D6/S\R\C\C\L\K\R\E\Q\1\_\N\)
WIFI_DISABLE#: CN22.54(W_DISABLE2* (O)(0/3.3V)) R240.1 R276.1 R330.2
WIFI_PCIE_CLK_DN: CN22.49(REFCLKN0) U1.CL2(CLKOUT_PCIE_N1)
WIFI_PCIE_CLK_DP: CN22.47(REFCLKP0) U1.CL1(CLKOUT_PCIE_P1)
WIFI_POWERON: R246.1 U9.76(TACH2A/GPJ0) U14.3(EN/ENB)
WIRELESS_ON: CN22.56(W_DISABLE1* (O)(0/3.3V)) U9.119(DSR0#/GPG6)
WLAN_PCIE_RST: R248.1 U1.DK38(GPP_H0/CNV_BT_I2S_SDO) U10.2(B)
WLAN_PCIE_WAKE#: CN22.55(PEWAKE0*) CN22.70(UIM_PWR_SRC/GPIO1/PEWAKE1*(I/O)) R150.2 R422.2
WLAN_PLT_RST: CN22.52(PERST0*) R244.2 U10.4(Y)
WLAN_WAKE_N: R422.1 R875.2 R876.1 U1.DJ38(GPP_H2/CNV_BT_I2S_SDO)
WRST#: C8.2 R238.1 U9.14(WRST#)
XCLK_BIASREF: R20.1 U1.DU6(XCLK_BIASREF)
XTAL1: C413.1 U30.28(CKXTAL1) X2.1
XTAL2: C1.1 U30.29(CKXTAL2) X2.3
XTAL24_IN: C11.1 R17.1 U1.DW8(XTAL_IN) X1.3
XTAL24_OUT: C13.1 R17.2 U1.DU8(XTAL_OUT) X1.1
N457881: CN22.64(RESERVED_64) R281.2 R440.2
N500287: C352.2 R206.1 U24.9(VCC)
N500381: C351.1 R208.1 R211.1 U24.10(FB/VOUT)
N500393: C349.2 U24.11(BYP/LDO)
N500423: R204.1 U24.12(ILMT/CLK)
N501011: C335.2 L7.1 U24.2(LX1) U24.3(LX2)
N501069: C351.2 R6.1
N501253: R5.1 U24.1(BOOT)
N501257: C335.1 R5.2
N775277: C458.1 R389.2 U25.27(LDO1-CAP)
N775289: C457.1 U25.34(CPVEE)
N775381: C467.2 U25.37(CBP)
N775429: C456.2 U25.28(VREF)
N775503: C470.2 R824.2
N775969: C467.1 U25.35(CBN)
N776445: ACN1.1 C6125.1 D65.N R391.1 R392.1 R824.1 R825.1
N776559: R407.1 U25.3(GPIO1/DMIC-CLK)
N776571: C461.2 C462.2 FB17.1 U25.36(CPVDD)
N776947: R406.2 U25.2(GPIO0/DMIC-DATA12)
N777173: R408.2 U25.4(DC_DET/EAPD)
N777797: R400.2 U25.12(I2C_SCL)
N777825: R401.2 U25.11(I2C_SDA)
N777887: C487.2 U25.7(LDO3-CAP)
N777931: R397.2 U25.48(SPDIFO/GPIO2)
N778447: FB34.2 R423.2
N778451: FB35.2 R425.2
N778639: R396.2 R398.2 U25.13(HP/LINE1 JD1)
N778927: C471.2 R825.2
N778973: R393.1 U25.20(5VSTB)
N779045: C475.2 U25.19(MIC-CAP)
N779197: C479.2 U25.16(PCBEEP)
N779371: C502.2 D55.N J7.4 R419.1 R823.1
N1014091: R192.1 R353.2 R354.2 U54.1(A)
N1016161: C281.2 U21.6(CT)
N1016367: D68.N D69.N R365.1
N1016683: D69.P R895.1 U54.4(Y)
N1017638: R365.2 R902.2 U21.3(ON)
N1064435: R369.1 U1.CH47(GPP_B14/SPKR/TIME_SYNC1/G\S\P\I)
N1064561: R370.1 U1.CL48(GPP_B23/S\M\L\1\A\L\E\R\T\_\N\/)
N1065581: R374.1 TP51.1 U1.DK21(GPP_C9/UART0_TXD)
N1170111: D21.N FIL1.3(DUMMY3) J1.2(D_MINUS) R424.2
N1170159: C234.1 FIL3.1(UNB) R431.1
N1170163: D22.N FIL1.2(DUMMY2) J1.3(D_PLUS) R427.2
N1170323: C233.1 FIL3.4(GND) R430.1
N1274442: C130.2 L6.1 MQ1.7(S1/D2) U2.16(PHASE)
N1320662: TP50.1 U1.DP21(GPP_C8/UART0_RXD)
N1407597: D7.N R444.1 R445.1
N1637434: CN22.38(RESERVED_38) R462.1
N1637496: CN22.40(RESERVED_40) R463.1
N1637500: CN22.42(RESERVED_42) R464.1
N1726762: R177.1 U1.DJ22(GPP_C11/U\A\R\T\0\_\C\T\S\_\N\)
N2010639: C30.2 U7.9(VCC)
N2010982: C17.2 L2.1 U7.2(LX1) U7.3(LX2)
N2400754: C197.1 R121.1 R123.1 U2.6(FB)
N2447682: D27.N FIL9.3(DUMMY3) J2.2(D_MINUS) R477.2
N2447732: C387.1 FIL11.1(UNB) R484.1
N2447742: D28.N FIL9.2(DUMMY2) J2.3(D_PLUS) R479.2
N2447932: C386.1 FIL11.4(GND) R483.1
N2461741: D34.N FIL4.3(DUMMY3) J4.3(D_PLUS) R314.2
N2461749: D35.N FIL4.2(DUMMY2) J4.2(D_MINUS) R448.2
N2465511: D36.N FIL14.3(DUMMY3) J5.3(D_PLUS) R488.2
N2465519: D37.N FIL14.2(DUMMY2) J5.2(D_MINUS) R491.2
N2477813: C191.2 R197.1 U4.4(SS)
N2478393: FIL18.2(DUMMY2) LJ1.7(P7) R500.1
N2478475: FIL17.3(DUMMY3) LJ1.5(P5) R499.1
N2478521: R362.1 U18.2(B)
N2478581: FIL16.2(DUMMY2) LJ1.6(P6) R497.1
N2478589: FIL15.2(DUMMY2) LJ1.1(P1) R494.1
N2478593: FIL15.3(DUMMY3) LJ1.2(P2) R495.1
N2478743: FIL16.3(DUMMY3) LJ1.3(P3) R496.1
N2478981: FIL17.2(DUMMY2) LJ1.4(P4) R498.1
N2479001: FIL18.3(DUMMY3) LJ1.8(P8) R505.1
N2484546: CN9.P7 R506.2
N2492664: C501.2 D54.N J7.3 R418.1 R822.1
N2496341: R507.2 R508.2 U25.14(MIC2/LINE2 JD2)
N2500362: CN14.5(RSVD2) R221.2
N2500386: CN14.1(WAKE#) D38.N
N2500440: CN14.18(GND8) R421.1
N2500754: CN14.26(GND9) R426.1 R509.1
N2500852: CN14.20(W_DISABLE#) R1395.1 R1396.1
N2500964: CN14.28(+1.5V_2) R510.1
N2501616: CN14.2(+3.3V_1) R59.2 R62.1
N2501758: R516.2 R517.1 U33.2(B)
N2502048: R513.2 R514.2 U32.4(Y)
N2505593: CN20.5 R564.1 R569.2
N2505601: CN20.7 R565.1 R570.1
N2505967: CN20.1 R562.1 R567.2
N2505977: CN20.3 R563.1 R568.2
N2506213: C509.2 R533.2
N2506315: Q34.2(S) R538.2 R539.2 R543.2 R551.2 R552.1
N2507261: Q34.1(G) R547.2
N2507331: D46.P D50.P L9.2 Q34.3(D)
N2514339: R576.1 R579.1 R580.1 R582.1 U39.3(ON)
N2514437: C517.1 R573.1 R574.1 R576.2 U39.1(VIN1) U39.2(VIN2)
N2514863: R585.2 R586.2 R587.2 U42.45(PWMI)
N2515735: PR107.2 R595.1 U43.7(WP/WC#)
N2516175: TP59.1 U42.20(TESTMODE)
N2516589: L10.2 U42.15(SW_OUT) U42.16(SW_OUT-1)
N2517121: C518.2 U39.6(CT)
N2567475: Q40.3(D) R210.1 R273.2 R364.2
N2631851: R125.1 U1.CL47(GPP_B20/GSPI1_CLK)
N2631888: R142.1 U1.CK47(GPP_B22/GSPI1_MOSI)
N2631892: R143.1 U1.CK46(GPP_B21/GSPI1_MISO)
N2631896: R144.1 U1.CH45(GPP_B19/G\S\P\I\1\_\C\S\0\_\N\)
N2652017: CN22.32(UART_TX/DP_ML0N) R161.2
N2652021: CN22.34(UART_CTS/DP_ML0P) R164.2
N2652047: CN22.36(GND_36) R166.2
N2652167: CN22.46(COEX2) R264.2
N2652171: CN22.48(COEX1) R274.2
N2652197: CN22.44(COEX3) R263.2
N2652755: CN22.22(UART_RX/DP_AUXP) R158.2
N2653101: CN22.50(SSCLK) R275.2
N2655807: CN22.53(CLKREQ0*) R145.1
N3254610: F8.1 FB2.2 FB7.2 FB10.2
N3254616: CN7.B D2.N F8.2
N3431626: C6059.1 TP35.1
N3431630: C6060.1 TP36.1
N3431634: C6061.1 TP37.1
N3431638: C6062.1 TP38.1
N3521964: C401.2 Q74.4(G) Q86.3(D) R815.2
N3521976: Q76.3(D) Q86.1(G) R791.2 R816.2
N4072078: R33.1 U7.1(BOOT)
N4072093: C17.1 R33.2
N5760544: R3.2 U1.CV39(GPP_A19/DDSP_HPD1/DISP_MISC1)
N5761208: R58.1 U1.DK17(GPP_E19/DDP1_CTRLDATA/TBT_LSX0_)
N5765083: C3.1 U1.DE4(PCIE5_TXN/USB31_5_TXN)
N5765087: C12.1 U1.DE3(PCIE5_TXP/USB31_5_TXP)
N5765191: C60.1 U1.DD1(PCIE6_TXN/USB31_6_TXN)
N5765195: C61.1 U1.DD2(PCIE6_TXP/USB31_6_TXP)
N5765627: C62.1 U1.DD3(PCIE7_TXN)
N5765631: C66.1 U1.DD5(PCIE7_TXP)
N5765735: C67.1 U1.DA3(PCIE8_TXN)
N5765739: C133.1 U1.DA5(PCIE8_TXP)
N5766195: C79.1 U1.CW2(PCIE11_TXN/SATA0_TXN)
N5766199: C81.1 U1.CW1(PCIE11_TXP/SATA0_TXP)
N5766235: C73.1 U1.DA2(PCIE9_TXN)
N5766239: C74.1 U1.DA1(PCIE9_TXP)
N5766259: C77.1 U1.CY3(PCIE10_TXN)
N5766263: C78.1 U1.CY4(PCIE10_TXP)
N5807743: C71.1 U1.CT2(PCIE14_TXN)
N5807747: C72.1 U1.CT1(PCIE14_TXP)
N5807759: C64.1 U1.CT3(PCIE13_TXN)
N5807763: C65.1 U1.CT5(PCIE13_TXP)
N5816743: C48.1 R81.2
N5816815: C85.1 R87.2
N5816861: C85.2 R45.1 U1.B45(DDR1_VREF_CA)
N5825064: R151.2 U1.C3(P\R\O\C\H\O\T\_\N\)
N5825723: R154.2 U1.CR38(GPP_B3/CPU_GP2)
N7408241: R252.2 R278.2 U1.DA47(GPP_R4/H\D\A\_\R\S\T\_\N\)
N7408375: R266.2 U1.CY46(GPP_R0/HDA_BCLK/I2S0_SCLK)
N7411390: TP3.1 U1.DW24(GPP_C13/UART1_TXD/ISH_UART1_TXD)
N7411394: R1390.2 U1.DK22(GPP_C12/UART1_RXD/ISH_UART1_RXD)
N7416143: R286.1 U1.DL31(GPP_F0/CNV_BRI_DT/U\A\R\T\0\_\R)
N7416157: R173.1 U1.DL29(GPP_F1/CNV_BRI_RSP/UART0_RXD)
N7416165: R284.1 U1.DP31(GPP_F2/CNV_RGI_DT/UART0_TXD)
N7416179: R287.1 U1.DN29(GPP_F3/CNV_RGI_RSP/U\A\R\T\0\_\)
N7426175: R68.1 U1.CL45(GPP_B12/S\L\P\_\S\0\_\N\)
N7426185: R83.1 U1.DF47(GPD4/S\L\P\_\S\3\_\N\)
N7426195: R103.1 U1.DC48(GPD5/S\L\P\_\S\4\_\N\)
N7426445: R101.2 U1.DM49(S\L\P\_\S\U\S\_\N\)
N7429515: R4.1 R22.2 R150.1 R223.1 R243.1 R439.1 U1.DL45(W\A\K\E\_\N\)
N7506400: R850.2 U1.DU47(VSS_432)
N7506448: R852.2 U1.C16(VSS_428)
N7506460: R851.2 U1.A16(VSS_429)
N7506476: R848.2 U1.J15(VSS_430)
N7507062: TP52.1 U1.T9(BPM_N_0)
N7562818: R307.1 U1.H1(V\I\D\A\L\E\R\T\)
N7628615: PR95.1 PR96.1 U3.27(TSEN)
N7628623: PR97.1 PR115.2
N7628627: PR94.1 PR114.2
N7628631: PR95.2 PR96.2 PR97.2 PR114.1
N7632263: PC15.1 PR41.1 U3.28(VIN)
N7679261: PR100.1 PR101.2
N7679265: PR101.1 PR102.2 PR103.1
N7679401: PR102.1 PR113.2
N7695190: PC14.1 PR12.1 PU3.8(VCC)
N7695204: PR11.2 PU3.1(EN)
N7695220: PR10.2 PU3.4(BOOT)
N7695396: PC12.1 PR10.1
N7794394: PR36.2 PR38.2 Q22.4(G)
N7794398: C6135.1 PR40.2 PR57.2 Q23.4(G)
N7794586: PC51.2 PR39.1
N7795972: PR32.2 U6.10(BOOT)
N7795976: PC50.1 PR32.1
N7796574: PC54.2 PC62.2 U6.5(COMP)
N7796578: PC54.1 PC63.2 PR63.2 PR108.1 U6.6(FB)
N7796616: PC62.1 PR63.1
N7797282: PR66.2 PR69.1 U6.7(RGND)
N7798637: PC55.1 R329.1 U6.20(VSYS)
N7841228: R330.1 U9.56(KSO16/SMOSI/GPC3)
N7843299: TP1.1 U9.4(KBRST#/GPB6)
N7844015: R352.2 R355.1 U9.125(SSCE1#/GPG0)
N7844027: R349.2 R350.1 U9.100(SSCE0#/GPG2)
N7847497: R356.2 U9.1(VSS)
N7847611: C9.1 U9.12(VCORE)
N7887361: R91.1 U9.25(PWM1/GPA1)
N7888127: R237.1 U9.117(SMCLK2/PECI/GPF6)
N7888705: R15.1 U9.67(ADC1/GPI1)
N7889662: R157.2 U9.97(GPH4/ID4)
N7929493: R375.2 U6.1(CS_DIS)
N7931680: R79.1 U9.107(GPE4/BTN#)
N8120641: CN11.166(SA2) R734.1 R736.1
N8123009: CN11.97(DQS8_T) R750.1
N8123013: CN11.95(DQS8_C) R751.1
N8123041: CN11.134(EVENT*) R733.2
N8132326: CN19.166(SA2) R236.1 R285.1
N8133152: CN19.134(EVENT*) R229.2
N8136392: CN19.97(DQS8_T) R302.1
N8136396: CN19.95(DQS8_C) R303.1
N8195134: R414.2 U1.CT49(GPP_A7/I2S2_SCLK)
N8195691: R214.2 U1.CT48(GPP_A8/I2S2_SFRM/C\N\V\_\R\F\_\)
N8195853: R416.2 U1.CV47(GPP_A10/I2S2_RXD)
N8195919: R417.2 U1.CT47(GPP_A9/I2S2_TXD/MODEM_CLKREQ)
N8196332: R433.2 U1.CN45(GPP_A0/ESPI_IO0)
N8196336: R437.1 U1.CR47(GPP_A5/ESPI_CLK)
N8196362: R435.2 U1.CN49(GPP_A2/ESPI_IO2)
N8196366: R434.2 U1.CN48(GPP_A1/ESPI_IO1)
N8196390: R436.2 U1.CN47(GPP_A3/ESPI_IO3)
N8234227: R441.1 U9.86(PS2DAT0/TMB1/GPF1)
N8275142: R10.1 U1.DN17(GPP_E20/DDP2_CTRLCLK/TBT_LSX1_T)
N8275166: R9.1 U1.DP17(GPP_E21/DDP2_CTRLDATA/TBT_LSX1_)
N8275258: R11.1 U1.DL40(GPP_H16/DDPB_CTRLCLK)
N8275262: R24.1 U1.DP42(GPP_H17/DDPB_CTRLDATA)
N8275836: R26.2 U1.CV45(GPP_R3/HDA_SDI0/I2S0_RXD)
N8278471: PC13.1 PR77.2 R304.2 U3.11(PSYS)
N8293543: PR13.2 Q7.3(D)
N8293743: PR71.2 Q10.3(D)
N9910984: PC56.1 PR98.2 U3.12(VCC)
N9913025: C465.1 PR78.2 U3.36(PVCC)
N9913597: PC57.1 PR81.1
N9918536: PR59.2 PR106.1 U3.15(RGND)
N9920429: PC22.1 PR112.2 U3.17(COMP)
N9920433: PC22.2 PC23.1 PR52.2 PR53.1 U3.18(FB)
N9920437: C526.2 PC23.2 PR51.1 PR52.1 PR70.1 U3.16(VSEN)
N9928220: PR3.1 PR6.1 U3.19(ANS_ EN)
N9929119: PC10.2 PR15.2
N9929123: PR15.1 U3.40(BOOT2)
N9929346: PC11.2 PR4.2
N9929352: PR4.1 U3.32(BOOT1)
N10068167: R379.2 R404.1 U1.DK29(GPP_F5/MODEM_CLKREQ)
N10069757: MQ1.6(G2) U2.15(LGATE)
N10070113: MQ1.1(GATE1) U2.17(UGATE)
N10071977: PR7.1 PR109.2
N10072699: PR8.1 PR110.2
N10073666: PR9.1 PR111.2
N10076660: PR46.1 PR79.1
N10624525: C378.2 R822.2
N10624529: C376.2 R823.2
N10677169: D64.N R418.2 R419.2
N11090699: R829.1 U9.29(PWM3/GPA3)
N11090809: R1391.1 U9.34(PWM7/RIG1#GPA7)
N11225851: D66.N D70.N D71.N R910.2 U15.3(ON) U56.4(Y)
N11237380: R847.2 U1.AV2(RSVD_TP_22)
N11237848: R849.2 U1.K15(VSS_431)
N11238399: TP65.1 U1.AD3(DDIB_AUX_N)
N11238403: TP66.1 U1.AD4(DDIB_AUX_P)
N11238439: R905.1 U1.DP15(GPP_E22/DDPA_CTRLCLK/PCIE_LNK_D)
N11238443: R904.1 U1.DJ17(GPP_E23/DDPA_CTRLDATA/BK4/SBK4)
N11546849: R199.2 U9.124(GPC6)
N11553427: PC63.1 PR62.1
N11601379: Q88.1(G) R862.2
N11605300: R168.2 U9.81(DAC5/RIG0#/GPJ5)
N11607400: R877.1 U1.DL38(GPP_H19/TIME_SYNC0)
N11607850: R153.2 R878.1 R879.1
N11609703: R880.1 R881.1 R882.2
N11610185: TP69.1 U1.P6(P\R\O\C\_\P\R\D\Y\_\N\)
N11610189: TP70.1 U1.M6(P\R\O\C\_\P\R\E\Q\_\N\)
N11610292: R883.1 R884.1 R885.2
N11610919: R886.1 R887.1 R888.2
N11611809: R890.1 R891.1 R892.2
N11612380: R893.1 R894.2
N11614712: R895.2 U16.3(ON)
N11616784: R215.2 R896.2 U51.5(EN)
N11617042: PC69.1 R897.2 R898.1 U7.6(EN)
N11618128: R36.1 U20.12(ILMT/CLK)
N11618501: R899.1 R900.1 U20.6(EN)
N11789303: R906.1 U1.DL33(GPP_D12/ISH_SPI_MOSI/DDP4_CTRLD)
N11789370: R907.1 U1.DL34(GPP_D10/ISH_SPI_CLK/DDP3_CTRLDA)
N11789662: TP71.1 U1.DL17(GPP_E18/DDP1_CTRLCLK/TBT_LSX0_T)
N11789666: TP72.1 U1.DK34(GPP_D9/ISH_SPI_CS_N/DDP3_CTRLCL)
N11789670: TP73.1 U1.DN33(GPP_D11/ISH_SPI_MISO/DDP4_CTRLC)
N11790522: R908.1 U1.DJ29(GPP_F4/C\N\V\_\R\F\_\R\E\S\E\T\)
N11790600: R909.1 U1.DL27(GPP_F19/A4WP_PRESENT)
N11802208: R911.1 U9.18(RI1#/GPD0)
N11806696: PR26.2 PR34.1
N11812447: PR53.2 PR112.1
N11813519: PR113.1 U3.13(IMON)
N11814979: PR25.1 PR28.1
N12024008: PC52.1 PR58.1 PR116.2 PR118.2
N12025327: PR60.2 PR118.1 PR119.2
N12070219: Q48.1(G) Q49.3(COLLECTOR) R1388.1
N12070227: Q49.1(BASE) R438.2
N12540155: D72.N D73.N R1392.1
N17228942: Q11.3(D) R201.1 R202.1 R249.1 R251.1 R253.1 R254.1 R255.1 R257.1
N17229240: Q11.1(G) R258.2
N19384822: C146.2 R245.1 U14.4(SS)
N19848028: CN10.38(DEVSLP (O)) R901.2
N19848541: CN10.41(PERN0/SATA-B+) R331.2
N19848543: CN10.43(PERP0/SATA-B-) R337.2
N19848545: C277.1 CN10.47(PETN0/SATA-A-)
N19848547: C278.1 CN10.49(PETP0/SATA-A+)
N19848677: R526.1 U40.2(B)
N19848727: CN10.50(PERST# (O)(0/3.3V) OR N/C) R525.2 U40.4(Y)
N20170654: D25.N Q72.1(IN)
N20170656: C642.1 R559.1
N20881703: Q12.1(G) Q13.3(D) R115.2
N20893807: Q15.2(S) R619.2 R622.2
N20893813: Q15.1(G) R624.1
N20893917: Q18.1(G) R629.1
N20893926: Q18.3(D) R628.2
N20896085: R665.2 U1.CN42(GPP_B6/ISH_I2C0_SCL)
N20896142: R664.2 U1.CN43(GPP_B5/ISH_I2C0_SDA)
N20896439: R680.1 U1.DU24(GPP_C15/U\A\R\T\1\_\C\T\S\_\N\/)
N20896443: R679.1 U1.DV24(GPP_C14/U\A\R\T\1\_\R\T\S\_\N\/)
N20896586: R649.2 U1.CF48(GPP_B18/GSPI0_MOSI)
N20896653: R650.1 U1.CH48(GPP_B16/GSPI0_CLK)
N20896704: R655.1 U1.CH49(GPP_B15/G\S\P\I\0\_\C\S\0\_\N\)
N20910631: D3.P R222.1
N20947983: R187.1 R225.2 U52.2(FB)
N20947999: C214.1 R195.1 U52.5(VIN1) U52.E1(VIN2)
N20948027: R183.1 R185.1 U52.8(EN)
N20948057: R182.2 U52.7(POK)
N20949015: R186.1 R188.1 U51.7(NC1)
N20949239: R191.1 R220.2 U51.6(FB)
N20949253: C205.1 C207.1 R184.1 R186.2 U51.8(VDD) U51.9(PVDD2) U51.10(PVDD1)
N20949292: L18.1 U51.2(LX1) U51.3(LX2)
N20954657: PR48.2 PR50.2 Q9.4(G)
N20954968: PR16.2 PR22.2 Q6.4(G)
N20954970: PR1.2 PR5.2 Q5.4(G)
N20955030: PC20.2 PR47.1
N20955067: PR43.2 PR44.2 Q8.4(G)
N20955215: PC7.2 PR14.1
N20955669: PR74.2 PR80.2 Q32.4(G)
N20955799: PC38.2 PR73.1
N20955838: PR65.2 PR67.2 Q29.4(G)
N20957599: PR21.2 PR33.1
N20957638: PR24.2 PR35.1
N20959230: C215.2 U16.6(CT)
N20959572: C10.2 U15.6(CT)
N20962294: C225.2 Q68.4(G) R789.1
N20962380: C224.2 Q56.4(G) R465.1
N20962423: Q71.1(G) R790.2
N20962724: Q78.3(D) R794.1
N20962834: Q80.3(D) R796.1
N20962840: Q81.3(D) R797.1
N20962846: Q83.3(D) R799.1
N20962856: Q85.3(D) R801.1
N20962894: Q84.3(D) R800.1
N20963383: C396.2 U55.6(CT)
N20968756: CN7.D R261.1
N20968842: Q30.3(D) R171.1
N21033241: Q44.3(D) R371.2 R385.2 U23.2(B)
N21033281: Q41.1(G) R390.1
N21033871: Q41.3(D) Q44.1(G) R386.2
N21324281: R78.1 U1.DW33(GPP_D14/ISH_UART0_TXD)
N22193769: C131.2 U2.4(VTTREF)
N22193795: R1.1 U2.18(BOOT)
N22193823: C197.2 R127.1
N22193910: Q4.3(D) R117.2
N22193984: R112.2 R120.1 U2.8(S5)
N22194036: R109.1 U2.9(TON)
N22194247: PR92.1 R56.1 U2.11(VID)
N22194263: R55.2 U2.13(CS)
N22194449: C130.1 R1.2
N22197677: C24.2 D6.3(D3)
N22197683: C28.1 D5.2(X2) D6.1(X1)
N22197720: C23.2 D5.3(D3)
N22197814: C333.2 U20.9(VCC)
N22197843: C332.1 R39.2 R40.1 U20.10(FB/VOUT)
N22198022: C31.2 L3.1 U20.2(LX1) U20.3(LX2)
N22198056: C332.2 R38.1
N22198095: R35.1 U20.1(BOOT)
N22198097: C31.1 R35.2
N34621689: Q36.3(OUT) R200.2
N34621695: LED2.2(N) R200.1
N77955914: TP58.1 U25.15(SPDIFO/FRONT JD3/GPIO3)
N77955916: TP57.1 U25.17(MIC2-L/RING2)
N77955917: TP56.1 U25.18(MIC2-R/SLEEVE)
N118215190: PR45.1 PR49.1
N780067955: TP63.1 U9.111(XLP_OUT/GPB4)

Pads without a net: CN3 13 14; CN9 P1 P2 P3 P11 P13 P14 P15; CN10 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67; CN22 6 16 24 25 26 27 28 29 30 31 62 66 68; MARK1 1; MARK2 1; MARK3 1; MARK4 1; MARK5 1; MARK6 1; MARK7 1; MARK8 1; U1 A4 A5 A7 A9 A12 A47 AE11 AF10 AH10 AJ11 AK10 AL3 AL5 AL11 AM10 AN3 AN5 AN7 AN9 AN11 AP10 AR5 AR6 AR10 AT1 AT2 AU1 AU2 AV1 AV5 AV6 AY5 AY6 B7 B9 B12 B47 BB1 BB2 BB5 BB6 BC10 BD1 BD2 BF1 BF2 BF5 BF6 BF38 BG5 BG6 BG11 BH1 BH2 BH10 BJ5 BJ6 BJ11 BJ47 BL1 BL2 BL10 BM1 BM2 BM36 BP5 BP6 BP36 BP41 BR1 BR2 BT1 BT2 BT5 BT6 BT36 BV5 BV6 BW11 C1 C2 C5 C7 C8 C9 C12 C33 CA11 CC5 CC6 CC45 CC47 CC48 CC49 CD3 CE46 CE47 CF3 CF5 CF45 CF49 CG32 CH33 CJ1 CJ2 CJ32 CJ39 CK33 CL32 CL39 CL41 CL43 CN32 CN41 CP3 CP5 CR3 CR4 CR39 CR43 CT32 CT38 CV32 CV37 CV41 CV43 CV48 CY35 CY37 CY38 CY39 CY43 D1 D4 D7 D8 D9 D12 D14 D33 DA11 DA45 DA48 DA49 DB37 DB39 DB41 DC7 DC9 DC45 DD38 DE7 DE9 DF1 DF2 DF3 DF5 DF37 DF41 DG38 DG40 DJ11 DJ34 DJ40 DK11 DK15 DK31 DK36 DK40 DL8 DL21 DL36 DN6 DN10 DN11 DN27 DN38 DN40 DP1 DP2 DP3 DP5 DP6 DP10 DP11 DP27 DP33 DP38 DP40 DR5 DT2 DT14 DT16 DT18 DT23 DT24 DT28 DT29 DT30 DT33 DT34 DT36 DT38 DT41 DU12 DU14 DU16 DU18 DU22 DU23 DU29 DU30 DU34 DU38 DU41 DU42 DV3 DV4 DV6 DV14 DV22 DV28 DV30 DV36 DV38 DV41 DW3 DW4 DW6 DW12 DW18 DW23 DW28 DW29 DW30 DW34 DW36 DW38 DW41 DW42 E1 E16 F6 F10 F13 F15 G6 G8 G10 G11 G13 G15 G34 H5 H34 J3 J8 J11 J34 K6 K10 K13 L6 L8 L10 L11 L13 L34 M8 M11 M13 M34 M38 M41 N34 P10 R1 V46 Y11; U3 1 3 20; U9 36 37 38 39 40 41 42 43 44 45 46 51 52 53 54 55 58 59 60 61 62 63 64 65; U13 1; U34 1; U42 55 56; U50 1; U51 1

## Via types
v1: diameter 0.45, hole 0.25, TOP to BOTTOM, 3302 vias
v2: diameter 0.7, hole 0.4, TOP to BOTTOM, 754 vias

# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+V3.3S on ART06 (solid shape): 31.6,53.78 31.62,53.68 31.63,53.59 31.63,52.41 31.62,52.32 31.6,52.22 31.6,51.41 32.37,50.64 42.37,50.64 47.02,45.99 64.75,45.99 66.93,48.17 70.39,48.17 70.75,47.81 70.75,46.84 70.12,46.21 68.05,46.21 66.32,44.48 66.3,44.47 66.28,44.46 46.39,44.46 41.79,49.07 31.79,49.07 30.08,50.78 30.08,52.39 30.08,52.49 30.1,52.58 30.1,53.59 30.12,53.73 30.16,53.87 30.32,54.03 31.35,54.03
+V3.3S on ART06 (solid shape): outline of 351 points within 95.78,65.8 125.15,76.63
+V3.3S_AUDIO on TOP (solid shape): 37.58,73.52 37.58,71.54 37.33,71.29 36.16,71.29 35.99,71.46 35.99,73.23 36.37,73.61 37.48,73.61
+V3.3S_DMIC on BOTTOM (solid shape): 133.11,60.01 133.18,60.02 133.46,60.02 133.5,60 133.54,59.98 133.61,59.96 133.68,59.96 133.7,59.95 133.72,59.94 133.89,59.77 133.89,58.42 133.84,58.37 132.64,58.37 132.55,58.46 132.55,59 132.55,58.99 132.55,59.9 132.67,60.02 133.05,60.02
+V3.3S_MSATA on TOP (solid shape): 101.18,57.14 101.29,57.02 101.29,55.78 101.06,55.54 96.4,55.54 96.3,55.65 96.3,56.14 101.14,56.14 101.14,56.31 99.57,56.31 99.57,56.14 96.3,56.14 96.3,56.64 101.14,56.64 101.14,56.81 99.57,56.81 99.57,56.64 96.3,56.64 96.3,57.07 96.37,57.14 99.57,57.14
+V3.3S_MSATA on TOP (solid shape): 98.11,75.15 98.11,74.5 98.43,74.17 101.12,74.17 101.19,74.11 101.19,73.86 101.17,73.82 101.14,73.81 99.57,73.81 99.57,73.64 101.14,73.64 101.17,73.62 101.19,73.59 101.19,73.39 101.2,73.35 101.19,73.34 101.17,73.32 101.14,73.31 99.57,73.31 99.57,73.29 99.28,73.29 99.16,73.17 99.16,71.78 99.31,71.63 101.11,71.63 101.14,71.61 101.16,71.58 101.16,71.36 101.14,71.32 101.11,71.31 99.57,71.31 99.57,71.14 101.11,71.14 101.14,71.12 101.16,71.09 101.16,70.86 101.14,70.82 101.11,70.81 99.57,70.81 99.57,70.64 101.11,70.64 101.14,70.62 101.16,70.59 101.16,70.36 101.14,70.32 101.11,70.31 99.57,70.31 99.57,70.14 101.11,70.14 101.14,70.12 101.16,70.09 101.16,69.86 101.14,69.82 101.11,69.81 99.57,69.81 99.03,69.81 99.03,69.8 98.84,69.61 98.84,66.73 98.77,66.52 98.84,66.3 98.84,64.49 98.56,64.22 95.94,64.22 95.45,64.71 95.45,75.33 95.6,75.48 97.78,75.48
+V3.3S_MSATA on BOTTOM (solid shape): 98.82,64.65 98.82,55.77 98.46,55.41 97.71,55.41 97.7,55.4 96.8,55.4 96.3,55.89 96.3,63.67 96.66,64.03 96.66,64.04 97.52,64.9 98.58,64.9
+V3P3_BIOS_SPI on TOP (solid shape): outline of 146 points within 134.8,64.44 142.37,68.79
+V3P3_DSW on TOP (solid shape): 136.35,79.42 139.34,79.42 139.79,78.97 139.79,75.74 139.62,75.57 129.09,75.57 128.54,76.12 128.54,76.51 128.6,76.71 128.54,76.91 128.54,79.04 128.93,79.42 136.34,79.42
+V3P3_DSW on BOTTOM (solid shape): outline of 333 points within 120.89,75.16 140.08,82.43
+V3P3A on BOTTOM (solid shape): 62.77,21.45 62.77,19.65 62.68,19.56 60.68,19.56 60.65,19.59 60.65,21.5 60.74,21.59 62.63,21.59
+V3P3A on BOTTOM (solid shape): 122.82,91.7 122.82,89.51 122.63,89.32 117.45,89.32 117.09,89.68 117.09,91.44 117.51,91.86 122.65,91.86
+V3P3A on BOTTOM (solid shape): 78.8,59.62 78.8,59.22 78.33,58.76 74.21,58.76 74,58.97 74,59.95 74.13,60.08 76.39,60.08 76.39,60.08 76.56,60.25 76.56,60.96 76.66,61.06 77.37,61.06
+V3P3A on BOTTOM (solid shape): 126.92,74.68 126.92,72.89 127.19,72.63 127.19,70.55 127.01,70.37 125.38,70.37 125.29,70.46 119.65,70.46 119.5,70.61 119.5,73.23 119.61,73.34 122.13,73.34 122.36,73.56 122.36,74.87 122.47,74.98 126.62,74.98
+V3P3A on BOTTOM (solid shape): outline of 122 points within 161.62,73.3 167.65,75.83
+V3P3A on ART03 (solid shape): outline of 127 points within 52.12,19.73 62.39,47.86
+V3P3A on PWR05 (solid shape): outline of 4017 points within 51.71,46.67 164.21,94.88
+V5_AVDD on TOP (solid shape): 25.55,88.73 25.78,88.61 26.07,88.66 26.09,88.65 26.19,88.55 26.19,86.56 25.92,86.29 25.14,86.29 24.99,86.44 24.99,87.57 24.83,87.72 24.06,87.72 24.03,87.73 24.02,87.74 23.93,87.83 23.82,87.88 23.8,87.88 23.78,87.91 23.78,88.65 23.95,88.82 25.46,88.82
+V5_AVDD on TOP (solid shape): 26.19,87.22 26.19,84.27 26.25,84.2 26.25,84.05 26.23,84.03 26.23,83.66 26.23,83.61 26.23,83.55 26.23,83.18 26.25,83.18 26.5,82.92 26.91,82.92 27.02,82.81 27.02,82.26 26.86,82.1 26.23,82.1 25.84,82.49 25.84,83.39 25.81,83.41 25.81,83.49 25.81,83.59 25.79,83.6 25.79,83.61 25.7,83.76 25.56,83.85 25.55,83.85 25.53,83.87 24.78,83.87 24.69,83.96 24.69,84.16 24.69,84.17 24.72,84.31 24.69,84.44 24.69,84.45 24.69,84.93 24.99,85.24 24.99,87.43 25.04,87.48 25.93,87.48
+V5_VCCIN_AUX_VCC on BOTTOM (solid shape): 170.48,97.27 170.48,96.52 168.51,94.55 165.64,94.55 165.56,94.63 165.56,95.55 165.62,95.61 165.85,95.61 165.85,95.84 165.96,95.95 167.09,95.95 167.17,95.91 167.19,95.83 167.51,95.42 167.94,95.72 168.08,95.85 168.88,95.85 169.59,96.56 169.59,97.31 169.67,97.39 170.36,97.39
+V5A on TOP (solid shape): 17.5,110.12 17.5,108.48 17.24,108.22 11.8,108.22 11.49,108.52 11.49,110.14 11.65,110.29 17.33,110.29
+V5A on TOP (solid shape): 60.66,113.79 60.83,113.62 60.83,111.92 60.58,111.66 54.83,111.66 54.74,111.76 54.74,113.44 55.08,113.79 60.3,113.79
+V5A on TOP (solid shape): 45.59,111.68 45.59,110.16 45.59,110.03 45.42,109.85 43.56,109.85 43.43,109.99 40.35,109.99 40.16,110.17 40.16,111.71 40.38,111.93 45.35,111.93
+V5A on TOP (solid shape): 92.5,81.33 92.5,77.71 91.78,76.99 91.78,73.07 91.66,72.95 91.07,72.95 90.48,72.36 84.5,72.36 82.68,74.19 82.68,74.75 82.58,74.85 82.58,80.58 83.46,81.46 92.37,81.46
+V5A on TOP (solid shape): 143.46,75.29 143.46,74.36 143.54,74.29 143.54,72.1 143.02,71.58 129.24,71.58 128.4,72.41 128.4,72.81 128.28,72.93 128.28,73.84 128.72,74.28 129.81,74.28 130.08,74 130.12,74 130.45,73.67 136.64,73.67 136.97,74 140.46,74 140.47,74.01 141.1,74.01 142.56,75.46 143.29,75.46
+V5A on BOTTOM (solid shape): 171.57,102.35 171.58,102.31 171.57,102.27 171.1,101.81 171.1,101.67 170.92,101.49 170.91,100.35 170.74,100.18 170.74,98.29 170.65,98.2 170.65,98.1 170.52,97.97 169.67,97.97 169.67,101.94 170.16,102.44 171.47,102.44
+V5A on BOTTOM (solid shape): outline of 2659 points within 10.59,75.11 98.68,114.47
+V5A on ART03 (solid shape): 131.35,72.91 131.35,72.39 131.09,72.13 128.81,72.13 128.48,72.46 128.48,73.84 128.67,74.03 130.23,74.03
+V5A on ART06 (solid shape): outline of 592 points within 89.24,72 129.45,80.71
+V5S on TOP (solid shape): 33.88,72.39 33.88,67.7 33.51,67.33 32.43,67.33 32.21,67.56 32.21,70.55 32.84,71.17 32.84,72.28 33.04,72.49 33.77,72.49
+V5S on TOP (solid shape): 26.82,56.38 26.82,54.96 26.31,54.45 22.15,54.45 22.14,54.45 22,54.48 21.86,54.45 21.85,54.45 21.31,54.45 21.16,54.6 21.16,56.2 21.52,56.56 26.65,56.56
+V5S on TOP (solid shape): outline of 162 points within 72.37,45.87 90.87,71.93
+V5S on BOTTOM (solid shape): 121.66,52.82 121.66,50.93 121.13,50.4 120.2,50.4 119.88,50.08 119.88,49.13 119.64,48.89 119.06,48.89 118.54,49.41 116.48,49.41 116.14,49.74 116.14,50.92 116.66,51.44 118.41,51.44 119.12,52.15 119.12,52.82 119.32,53.03 121.45,53.03
+V5S on BOTTOM (solid shape): 62.85,15.36 62.85,13.99 62.28,13.42 61.01,13.42 60.99,13.42 60.97,13.44 60.81,13.58 60.6,13.62 60.52,13.64 60.48,13.72 60.48,13.79 60.02,13.79 59.54,14.27 59.54,15.12 59.98,15.56 62.14,15.56 62.14,15.56 62.65,15.56
+V5S on BOTTOM (solid shape): 233.82,31.76 233.84,31.76 233.86,31.74 233.87,31.71 233.87,29.96 232.93,29.02 232.93,21.91 233.19,21.65 233.19,19.87 233.2,19.86 233.2,16.19 232.96,15.95 231.67,15.95 231.39,16.23 231.39,16.73 231.39,21.13 231.39,21.21 231.13,21.47 231.06,21.53 231.06,26.22 231.92,26.22 231.92,26.16 231.94,26.11 231.96,26.06 231.98,26.01 232.02,25.96 232.06,25.93 232.1,25.89 232.15,25.87 232.2,25.85 232.26,25.84 232.31,25.84 232.37,25.84 232.42,25.86 232.47,25.88 232.52,25.91 232.56,25.94 232.6,25.99 232.63,26.03 232.65,26.08 232.67,26.13 232.68,26.19 232.68,26.24 232.67,26.3 232.65,26.35 232.63,26.4 232.6,26.45 232.56,26.49 232.52,26.52 232.47,26.55 232.42,26.57 232.37,26.59 232.31,26.59 232.26,26.59 232.2,26.58 232.15,26.56 232.1,26.54 232.06,26.51 232.02,26.47 231.98,26.43 231.96,26.38 231.94,26.33 231.92,26.27 231.92,26.22 231.06,26.22 231.06,28.23 231.1,28.27 231.76,28.92 233.39,30.55 233.39,31.71 233.4,31.74 233.41,31.76 233.44,31.76
+V5S on PWR05 (solid shape): outline of 5710 points within 23.41,52.68 91.46,75.36
+V5S on ART06 (solid shape): 101.17,52.31 105.3,52.31 105.37,52.27 105.4,52.19 105.61,51.75 106.07,51.88 106.13,51.92 106.19,51.91 106.27,51.83 106.6,51.83 106.84,52.07 106.84,52.1 107.05,52.31 109.85,52.31 111.07,51.08 112.11,51.08 112.33,51.01 112.56,51.08 112.96,51.08 112.97,51.08 113.11,51.05 113.25,51.08 113.26,51.08 113.91,51.08 114.27,51.44 117.35,51.44 117.7,51.08 135.82,51.08 136.94,49.96 136.94,48.73 136.69,48.49 136.46,48.49 136.39,48.55 136.39,48.55 136.13,48.81 136.13,48.82 136.01,49.02 135.81,49.14 135.8,49.14 135.73,49.21 131.35,49.21 130.89,49.66 109.45,49.66 108.76,50.35 108.7,50.35 108.68,50.37 100.21,50.37 99.42,51.16 99.39,51.16 98.78,51.76 89.1,51.76 88.49,51.16 87.76,51.16 87.56,51.36 87.56,52.52 88.32,53.28 100.2,53.28
+V5S on ART06 (solid shape): outline of 260 points within 18.63,54.54 33.94,89.89
+V5S on ART06 (solid shape): outline of 315 points within 60.16,12.9 75.82,48.52
+V5S_CAM on TOP (solid shape): 140.29,48.31 140.29,48.31 140.49,48.1 142.75,48.1 142.84,48.02 142.84,46.93 143.01,46.75 143.52,46.75 143.6,46.67 143.6,45.26 143.31,44.97 139.27,44.97 139.27,44.97 138.99,44.97 138.56,45.4 136.74,46.8 134.63,47.68 134.46,47.84 134.46,48.86 134.72,49.11 139.48,49.11
+V5S_CAM on BOTTOM (solid shape): 127.66,52.42 127.66,51.26 127.65,51.26 128.61,50.3 135.33,50.3 136.18,49.45 136.18,48.18 136.01,48.01 134.92,48.01 134.44,48.5 127.45,48.5 126.13,49.82 124.54,49.82 124.26,50.1 124.26,50.77 124.05,50.98 122.6,50.98 122.29,51.29 122.29,52.59 122.68,52.98 127.1,52.98
+V5S_HDD on TOP (solid shape): 20.81,64 23.01,61.79 23.47,61.33 23.47,57.14 23.26,56.92 21.06,56.92 20.82,57.16 20.82,59.95 17.18,63.6 15.42,63.6 15.13,63.88 15.13,65.75 15.32,65.94 18.87,65.94
+VCC1.05_OUT_FET on TOP (solid shape): 190.08,89.94 190.08,88.93 189.98,88.83 188.55,88.83 188.35,88.63 188.35,87.92 188.19,87.75 187.95,87.75 187.62,87.42 187.62,87.27 187.22,86.87 187.22,86.42 187.03,86.23 187.03,86.12 187.03,86.08 187.04,86.03 187.04,85.95 187.2,85.8 187.63,85.8 187.73,85.7 188.02,85.7 188.07,85.65 188.07,85.31 187.91,85.14 187.01,85.14 186.52,85.63 186.51,85.65 186.51,85.67 186.51,86.05 186.64,86.18 186.64,87.01 186.65,87.04 186.67,87.06 186.79,87.15 186.87,87.27 186.87,87.29 187.13,87.54 187.13,87.88 187.13,87.89 187.16,88.04 187.13,88.19 187.13,88.2 187.13,88.23 187.31,88.41 187.31,89.89 187.45,90.03 190,90.03
+VCC1.05_OUT_PCH_R on ART03 (solid shape): 175.77,73.04 175.77,71.58 175.6,71.42 174.42,71.42 174.28,71.56 174.28,71.87 174.47,71.87 174.47,71.82 174.47,71.77 174.49,71.72 174.51,71.68 174.54,71.64 174.58,71.6 174.62,71.57 174.67,71.55 174.72,71.53 174.77,71.52 174.82,71.52 174.87,71.53 174.92,71.55 174.96,71.57 175.01,71.6 175.04,71.64 175.07,71.68 175.1,71.72 175.11,71.77 175.12,71.82 175.12,71.87 175.11,71.92 175.1,71.97 175.07,72.02 175.04,72.06 175.01,72.1 174.96,72.13 174.92,72.15 174.87,72.17 174.82,72.17 174.77,72.17 174.72,72.17 174.67,72.15 174.62,72.13 174.58,72.1 174.54,72.06 174.51,72.02 174.49,71.97 174.47,71.92 174.47,71.87 174.28,71.87 174.28,72.97 174.45,73.14 175.67,73.14
+VCC1.05_OUT_SFR on TOP (solid shape): 186.74,87.69 186.74,87.38 186.49,87.13 186.49,86.3 186.05,85.86 185.92,85.86 185.8,85.98 185.8,86.15 185.95,86.3 185.96,86.3 186.13,86.46 186.14,86.7 186.14,86.71 186.14,87.55 186.35,87.76 186.67,87.76
+VCC1.05_OUT_SFR on BOTTOM (solid shape): 187.7,89.16 187.7,88.11 187.38,87.78 186.69,87.78 186.6,87.69 186.6,87.48 186.51,87.4 186,87.4 185.77,87.63 185.77,88.9 185.94,89.08 186.4,89.08 186.54,89.22 187.65,89.22
+VCC_EFUSEPRG on TOP (solid shape): 220.22,71.08 220.22,70.55 220.16,70.49 217.31,70.49 217.27,70.45 216.37,70.45 216.24,70.57 216.24,70.74 216.27,70.76 216.28,70.77 216.39,70.81 216.47,70.88 216.49,70.9 216.51,70.9 216.56,70.9 216.57,70.89 216.8,70.79 217.03,70.89 217.05,70.9 217.07,70.9 217.18,70.9 217.47,71.2 220.11,71.2
+VCCDSW_1P05 on BOTTOM (solid shape): 177.27,69.84 177.29,69.83 177.29,69.81 177.29,69.78 177.26,69.64 177.29,69.52 177.29,69.51 177.29,69.47 177.46,69.3 177.46,68.72 177.44,68.72 177.44,68.19 177.32,68.06 177.3,68.05 177.28,68.05 176.74,68.05 176.57,68.22 176.57,68.55 176.6,68.62 176.68,68.65 177.02,68.98 176.68,69.31 176.55,69.31 176.38,69.47 176.38,70.03 176.49,70.13 176.98,70.13
+VCCFPGM on TOP (solid shape): outline of 247 points within 206.48,69.22 211.87,71.08
+VCCFPGM on BOTTOM (solid shape): 210.78,70.81 211.7,70.81 211.71,70.81 211.82,70.79 211.94,70.81 211.94,70.81 212.36,70.81 212.36,70.8 212.68,70.8 212.74,70.8 212.9,70.8 213.26,70.43 213.26,69.69 212.99,69.41 211.57,69.41 211.51,69.48 209.97,69.48 209.83,69.63 206.84,69.63 206.66,69.81 206.66,71.44 206.95,71.74 209.85,71.74
+VCCIN on TOP (solid shape): 208.2,80.79 208.23,80.78 208.24,80.75 208.36,80.62 208.53,80.59 208.56,80.58 208.58,80.56 208.62,80.5 208.62,80.25 208.59,80.2 208.57,80.17 208.55,80.15 208.52,80.14 208.34,80.09 208.26,79.92 208.23,79.85 208.15,79.82 208.1,79.82 207.93,79.64 207.93,79.09 207.85,79.01 205.91,79.01 205.88,79.03 205.86,79.07 205.86,79.3 205.91,79.39 206.02,79.39 206.51,79.67 206.02,79.95 205.91,79.95 205.86,80.04 205.86,80.58 205.87,80.61 206.12,80.78 206.27,80.78 206.51,80.63 206.66,80.58 206.8,80.63 207.03,80.78 207.28,80.78 207.31,80.77 207.33,80.75 207.57,80.58 207.81,80.75 207.83,80.78 207.86,80.79
+VCCIN on TOP (solid shape): outline of 373 points within 183.01,80.31 191.82,82.77
+VCCIN on TOP (solid shape): outline of 253 points within 179.19,68.43 189.55,71.55
+VCCIN on TOP (solid shape): outline of 2287 points within 180.83,70.41 232.13,100.42
+VCCIN on BOTTOM (solid shape): outline of 4588 points within 179.83,68.73 231.83,98.11
+VCCIN on ART03 (solid shape): 190.98,95.29 196.96,95.29 197.54,94.71 197.54,93.56 196.41,92.42 189.2,92.42 187.85,93.78 187.85,96.48 188.22,96.85 189.42,96.85
+VCCIN on ART03 (solid shape): 216.12,94.34 222.71,94.34 223.38,93.68 223.38,91.41 222.62,90.66 219.49,90.66 217.55,92.59 206.62,92.59 205.9,93.31 205.9,94.34 206.75,95.19 215.27,95.19
+VCCIN on ART03 (solid shape): outline of 2433 points within 184.03,67.93 231.66,90.45
+VCCIN on ART06 (solid shape): outline of 7808 points within 178.66,68.84 232.12,97.1
+VCCPDSW_3P3 on BOTTOM (solid shape): outline of 211 points within 169.09,69.9 176.42,71.88
+VCCPGPPR_3P3_1P8 on BOTTOM (solid shape): 177.33,76.4 177.33,75.65 177.79,75.18 177.79,74.63 177.68,74.51 177.08,74.51 177.02,74.57 177.02,74.83 176.55,75.29 176.55,76.42 176.62,76.49 177.24,76.49
+VCCPGPPR_3P3_1P8 on ART03 (solid shape): outline of 83 points within 175.14,73.73 177.18,75.94
+VCCPLL on TOP (solid shape): 186.4,85.53 186.4,85.25 186.4,85.04 186.73,84.7 186.73,84.5 186.65,84.41 186.58,84.4 186.52,84.37 186.51,84.36 186.31,84.36 186.2,84.47 186.2,84.69 186.2,84.7 186.23,84.81 186.2,84.93 186.16,84.99 186.12,85.02 185.87,85.28 185.87,85.33 185.83,85.36 185.83,85.6 185.91,85.68 186.25,85.68
+VCCPLL on BOTTOM (solid shape): 187.55,87.5 187.63,87.46 187.64,87.36 187.64,87.14 187.77,86.97 187.82,86.89 187.79,86.81 188.05,86.25 188.19,86.85 188.15,86.92 188.18,87.01 188.27,87.17 188.25,87.36 188.26,87.46 188.35,87.5 188.9,87.5 189.09,87.32 189.09,85.92 188.66,85.5 188.08,85.5 187.81,85.22 187.81,84.86 186.91,83.96 186.18,83.96 186.18,83.96 186.06,83.98 185.94,83.96 185.93,83.96 185.77,83.96 185.67,84.06 185.67,84.67 186.12,85.12 186.12,86.46 186.13,86.47 186.13,86.72 185.95,86.91 185.94,86.91 185.85,87 185.85,87.2 185.86,87.23 185.88,87.25 185.9,87.26 185.93,87.25 185.94,87.24 186.57,87.24 186.75,87.42 186.75,87.45 186.76,87.49 186.8,87.5
+VCCPRTC_3P3 on BOTTOM (solid shape): outline of 293 points within 169.19,68.67 176.16,70.44
+VCCSFR_OC on BOTTOM (solid shape): outline of 308 points within 163.11,49.55 185.72,68
+VCCSTG_OUT_FUSE on TOP (solid shape): 214.37,71.33 214.56,71.26 214.76,71.33 215.02,71.33 215.12,71.28 215.26,71.26 215.28,71.25 215.48,71.05 215.48,70.97 215.43,70.88 215.33,70.88 215.02,70.82 215.02,70.49 215.03,70.38 214.94,70.33 214.9,70.33 214.79,70.31 214.68,70.22 213.62,70.22 213.56,70.28 213.56,70.64 213.96,71.19 214.08,71.31 214.11,71.33
+VCCSTG_OUT_FUSE on BOTTOM (solid shape): 215.29,71.47 215.29,70.37 215.27,70.33 215.26,70.32 215.16,70.19 215.13,70.04 215.16,69.92 215.23,69.82 215.25,69.79 215.23,69.75 214.81,69.33 213.58,69.33 213.46,69.45 213.46,70.69 213.31,70.84 213.31,71.42 213.43,71.54 215.22,71.54
+VDDQ_MEM on TOP (solid shape): 187.16,63.03 187.16,62.83 187.15,62.77 186.95,62.34 186.95,61.36 187.37,60.94 187.37,60.16 187.3,60.09 186.29,60.09 186.22,60.16 186.22,61.62 186.68,62.08 186.68,62.93 186.82,63.07 187.12,63.07
+VDDQ_MEM on TOP (solid shape): outline of 101 points within 124.04,49.36 143.32,54.77
+VDDQ_MEM on TOP (solid shape): outline of 345 points within 189.7,67.07 193.76,69.83
+VDDQ_MEM on TOP (solid shape): outline of 252 points within 193.61,68.04 207.34,70.84
+VDDQ_MEM on BOTTOM (solid shape): 162.09,51.61 162.09,51.01 162.09,51 162.09,50.91 162.12,50.88 162.12,50.8 162.2,50.8 162.22,50.79 162.31,50.79 162.4,50.69 162.4,49.61 162.26,49.47 161.15,49.47 160.76,49.86 160.76,50.22 160.73,50.27 159.93,50.27 159.93,50.25 159.33,50.25 158.99,50.6 158.99,51.33 159.2,51.53 160.99,51.53 161.14,51.68 162.01,51.68
+VDDQ_MEM on BOTTOM (solid shape): outline of 5739 points within 186.27,58.44 215.12,70.29
+VDDQ_MEM on BOTTOM (solid shape): outline of 13123 points within 140.22,11.86 216.49,55.18
+VDDQ_MEM on GND04 (solid shape): outline of 7999 points within 182,7.31 220.17,71.86
+VDDQ_MEM on PWR05 (solid shape): outline of 2834 points within 139.45,18.55 161.05,55.46
+VDDQ_MEM on PWR05 (solid shape): outline of 9406 points within 176.92,13.02 216.84,71.67
+VDDQ_VTT on BOTTOM (solid shape): 116.04,53.27 116.53,53.27 116.59,53.2 118.11,53.2 118.4,52.92 118.4,52.18 118.08,51.86 116.92,51.86 116.84,51.87 116.75,51.86 116.5,51.86 115.67,51.04 114.81,51.04 114.48,51.37 114.48,53.07 114.54,53.14 114.64,53.14 114.72,53.06 114.72,52.38 114.86,52.25 115.12,52.25 115.28,52.41 115.28,53.47 115.35,53.54 115.77,53.54
AGND on GND02 (solid shape): outline of 1748 points within 0.41,72.36 33.74,107.56
AGND on GND07 (solid shape): outline of 792 points within 1.28,90.03 12.96,107.28
AVDD33_REG on BOTTOM (solid shape): 70.16,66.69 70.16,66.13 70.09,66.06 69.64,66.06 69.38,65.8 69.38,65.01 69.79,64.6 69.79,62.25 69.71,62.16 68.65,62.16 68.57,62.25 68.57,65.88 69.4,66.72 70.13,66.72
GND on TOP (solid shape): 14.52,113.43 14.52,111.1 14.44,111.02 13.27,111.02 13.02,111.27 13.02,113.58 13.2,113.75 14.19,113.75
GND on TOP (solid shape): 25.21,110.61 25.21,107.33 25.08,107.2 22.57,107.2 22.41,107.37 22.41,110.46 22.81,110.86 24.95,110.86
GND on TOP (solid shape): 32.06,75.38 32.06,74.71 31.81,74.45 30.46,74.45 30.31,74.61 30.31,75.38 30.36,75.43 32,75.43
GND on TOP (solid shape): 37.13,109.2 37.13,108.35 36.99,108.21 35.22,108.21 35.09,108.33 35.09,109.14 35.58,109.62 36.71,109.62
GND on TOP (solid shape): 51.57,110.98 51.57,109.4 51.4,109.24 49.78,109.24 49.35,109.66 49.35,110.95 49.52,111.11 51.43,111.11
GND on TOP (solid shape): 54.12,20.67 54.12,16.42 53.66,15.95 51.67,15.95 51.22,16.4 51.22,19.32 52.83,20.92 53.86,20.92
GND on TOP (solid shape): 55.71,109.18 55.71,107.87 55.34,107.5 54.17,107.5 53.83,107.84 53.83,109.24 53.94,109.35 55.54,109.35
GND on TOP (solid shape): 59.79,110.94 59.79,109.2 59.55,108.96 58.28,108.96 57.73,109.5 57.73,111.08 57.87,111.22 59.52,111.22
GND on TOP (solid shape): 94.37,106.56 94.37,105.21 94.06,104.9 91.54,104.9 91.4,105.04 91.4,105.81 92.25,106.66 94.27,106.66
GND on TOP (solid shape): 95.13,76.59 95.13,73.26 94.86,72.99 92.22,72.99 92.05,73.16 92.05,76.6 92.2,76.75 94.97,76.75
GND on TOP (solid shape): 104.4,95.22 104.4,93 103.81,92.42 95.44,92.42 95.25,92.61 95.25,95.3 95.56,95.6 104.01,95.6
GND on TOP (solid shape): 131.17,89.68 131.17,88.2 131.07,88.1 128.14,88.1 128.09,88.15 128.09,89.72 128.16,89.8 131.06,89.8
GND on TOP (solid shape): 140.37,83.93 140.37,81.28 139.28,80.19 136.61,80.19 135.32,81.48 135.32,83.82 136.54,85.03 139.27,85.03
GND on TOP (solid shape): 141.5,90.25 141.5,88.33 141.24,88.06 138.72,88.06 138.52,88.27 138.52,89.53 139.31,90.32 141.43,90.32
GND on TOP (solid shape): 151.09,72.33 151.09,71.07 150.73,70.71 149.49,70.71 149.19,71.01 149.19,72.37 149.29,72.47 150.94,72.47
GND on TOP (solid shape): 151.21,44.09 151.21,39.82 150.33,38.94 149.05,38.94 148.19,39.8 148.19,44.93 148.48,45.23 150.07,45.23
GND on TOP (solid shape): 151.24,95.28 151.24,93.79 151.04,93.58 146.73,93.58 146.44,93.87 146.44,95.4 146.55,95.51 151.02,95.51
GND on TOP (solid shape): 209.47,115.45 209.47,114.34 209.18,114.04 197.62,114.04 197.39,114.27 197.39,115.22 197.87,115.69 209.23,115.69
GND on TOP (solid shape): 231.8,28.15 231.8,22.15 231.2,21.55 229.23,21.55 228.9,21.88 228.9,28.32 229.34,28.76 231.19,28.76
GND on TOP (solid shape): 167.24,92.04 167.25,92.04 167.25,91.37 167.17,91.29 164.64,91.29 164.22,91.71 164.22,91.99 164.36,92.12 167.16,92.12
GND on TOP (solid shape): 14.68,112.25 15.3,112.25 15.46,112.09 15.46,110.84 15.22,110.6 13.8,110.6 13.42,110.97 13.42,112.03 13.93,112.53 14.39,112.53
GND on TOP (solid shape): 26.25,61.06 26.25,57.17 25.93,56.85 23.94,56.85 23.85,56.94 23.85,57.65 23.85,57.65 23.85,61.09 23.94,61.18 26.13,61.18
GND on TOP (solid shape): 31.87,70.65 31.87,69.45 31.86,69.45 31.86,68.37 31.67,68.18 30.44,68.18 30.28,68.34 30.28,70.61 30.43,70.76 31.75,70.76
GND on TOP (solid shape): 35.61,69.03 35.61,66.65 35.44,66.47 34.43,66.47 34.3,66.6 34.3,68.85 34.29,68.86 34.29,69.03 34.44,69.18 35.46,69.18
GND on TOP (solid shape): 59.58,111.08 59.58,110.21 58.83,109.46 57.32,109.46 57.09,109.7 57.09,110.31 56.54,110.85 56.54,111.36 56.67,111.49 59.17,111.49
GND on TOP (solid shape): 93.29,70.84 93.29,68.55 93.16,68.41 91.37,68.41 91.18,68.6 91.18,70.62 91.18,70.62 91.18,70.88 91.26,70.96 93.17,70.96
GND on TOP (solid shape): 98.22,81.17 101.01,81.17 101.26,80.92 101.26,78.83 100.98,78.54 93.61,78.54 93.15,79 93.15,81.27 93.63,81.75 97.64,81.75
GND on TOP (solid shape): 108.67,105.91 109.75,105.91 110.16,105.5 110.16,103.09 109.37,102.3 102.6,102.3 101.75,103.15 101.75,105.57 102.09,105.91 108.66,105.91
GND on TOP (solid shape): 164.9,91.86 165.01,91.86 165.13,91.74 165.13,91.46 164.92,91.25 163.48,91.25 163.43,91.29 163.43,91.89 163.69,92.15 164.61,92.15
GND on TOP (solid shape): 206.29,104.98 206.29,102.16 205.99,101.86 197.57,101.86 197.23,102.21 197.23,104.12 197.94,104.83 200.64,104.83 201.04,105.23 206.04,105.23
GND on TOP (solid shape): 224.74,9.15 225.76,9.15 226.51,8.4 226.51,7.2 226.36,7.05 223.18,7.05 222.85,7.38 222.85,8.75 223.25,9.16 224.73,9.16
GND on TOP (solid shape): 226.56,42.73 228.02,42.73 228.48,42.28 228.48,37.98 228.18,37.68 224.65,37.68 224.46,37.87 224.46,43.39 224.66,43.58 225.72,43.58
GND on TOP (solid shape): 94.29,84.96 95.24,84.96 95.55,84.66 95.55,83.51 94.99,82.95 91.94,82.95 91.44,83.44 91.44,85.71 91.56,85.83 93.42,85.83
GND on TOP (solid shape): 32.66,72.72 32.66,71.5 32.66,71.5 32.66,71.3 32.49,71.12 29.85,71.12 29.75,71.23 29.75,72.06 30.16,72.47 30.16,72.75 30.27,72.87 32.51,72.87
GND on TOP (solid shape): 128.58,65.58 128.58,64.99 129.41,64.16 129.41,60.9 128.75,60.24 124.26,60.24 124.17,60.32 124.17,60.85 125.08,61.75 125.08,65.58 125.3,65.81 128.35,65.81
GND on TOP (solid shape): 128.77,113.23 128.77,112.01 129.59,111.18 130.32,111.18 130.38,111.13 130.38,110.61 130.32,110.56 126.84,110.56 126.57,110.82 126.57,113.33 126.79,113.55 128.45,113.55
GND on TOP (solid shape): 139.39,58.7 142.4,58.7 142.99,58.11 142.99,55.24 142.87,55.13 142.03,55.13 142,55.16 130.3,55.16 129.71,55.75 129.71,58.89 129.88,59.05 139.04,59.05
GND on TOP (solid shape): 146.32,70.79 146.32,70.2 146.42,70.1 147,70.1 147.07,70.03 147.07,69.41 146.97,69.31 145.3,69.31 145.16,69.45 145.16,70.62 145.4,70.86 146.25,70.86
GND on TOP (solid shape): 150.76,110.86 150.76,109.5 150.22,108.96 144.07,108.96 144.04,108.98 144.02,109.01 144.02,110.89 144.46,111.33 150.29,111.33
GND on TOP (solid shape): 175.63,115.51 176.71,115.51 177.2,115.02 177.2,113.68 176.59,113.07 169.98,113.07 169.2,112.29 166.26,112.29 165.74,112.8 165.74,115.23 166.04,115.53 175.61,115.53
GND on TOP (solid shape): 234.39,115.5 234.39,113.39 234.27,113.26 231.35,113.26 230.95,113.66 230.95,114.27 230.76,114.46 230.13,114.46 229.78,114.82 229.78,115.51 229.96,115.69 234.2,115.69
GND on TOP (solid shape): 143.6,49.4 143.6,48.4 143.5,48.31 143.04,48.31 142.74,48.61 140.64,48.61 140.55,48.69 140.55,49.5 140.62,49.57 140.64,49.58 140.66,49.58 143.42,49.58
GND on TOP (solid shape): 188.29,91.57 188.29,90.46 188.14,90.31 187.28,90.31 187.11,90.13 187.11,89.38 187.08,89.36 185.59,89.36 185.48,89.47 185.48,91.73 185.71,91.96 187.89,91.96
GND on TOP (solid shape): 43.49,109.59 44.5,109.59 45,109.09 45,107.67 44.74,107.41 43.21,107.41 42.96,107.65 42.96,108.03 42.71,108.27 42.26,108.27 42.14,108.4 42.14,109.67 42.22,109.75 43.32,109.75
GND on TOP (solid shape): 195.65,115.14 195.65,114.72 195.58,114.66 195.58,112.59 194.84,111.84 191.86,111.84 191.78,111.93 191.78,112.92 192.1,113.24 192.1,114.36 191.75,114.7 191.75,115.32 192.1,115.66 195.12,115.66
GND on TOP (solid shape): 123.73,83.14 123.73,82.09 123.72,82.01 123.73,81.92 123.73,81.57 123.58,81.42 121.5,81.42 121.33,81.59 121.33,83.15 121.53,83.35 123.52,83.35
GND on TOP (solid shape): 147.32,75.95 147.32,74.59 147.12,74.38 146.15,74.38 145.99,74.22 144.05,74.22 143.77,74.51 143.77,75.33 143.89,75.45 145.6,75.45 145.69,75.54 145.76,75.54 145.76,75.6 146.3,76.15 147.13,76.15
GND on TOP (solid shape): 188.23,115.25 188.23,113.26 188.65,112.85 188.65,112.03 188.22,111.61 184.67,111.61 184.6,111.68 184.6,112.88 184.5,112.98 184.5,113 184.48,113 184.18,113.3 184.18,115.26 184.48,115.57 187.92,115.57
GND on TOP (solid shape): 155.72,93.18 155.72,91.9 155.7,91.86 155.67,91.85 155.33,91.85 155.07,91.59 153.6,91.59 153.47,91.73 153.47,92.13 153.88,92.54 154.41,92.54 155.09,93.22 155.68,93.22
GND on TOP (solid shape): 39.92,109.5 39.92,109.11 39.67,108.86 37.8,108.86 37.76,108.83 37.66,108.83 37.66,108.72 37.5,108.56 37.5,107.92 37.4,107.83 36.77,107.83 36.51,108.09 34.81,108.09 34.38,108.52 34.38,109.1 34.91,109.64 39.78,109.64
GND on TOP (solid shape): 116,64.12 116,61.76 115.97,61.73 115.66,61.73 115.64,61.74 115.47,61.78 115.3,61.74 115.29,61.73 114.88,61.73 114.13,62.49 114.13,63.17 115.18,64.22 115.9,64.22
GND on TOP (solid shape): 166.62,115.69 166.66,115.68 166.67,115.64 166.67,115.27 166.4,115 150.03,115 148.74,113.71 134.49,113.71 132.87,115.32 126.74,115.32 126.55,115.52 126.53,115.63 126.62,115.69
GND on TOP (solid shape): 72.93,28.03 72.93,14.55 72.13,13.76 72.13,10.92 72.13,10.91 72.12,10.89 71.85,10.62 67.88,10.62 66.82,11.68 66.82,16.27 67.8,17.25 67.8,25.29 67.81,25.3 67.82,25.4 67.81,25.51 67.8,25.51 67.8,25.93 69.56,27.69 69.56,28.81 69.65,28.9 72.05,28.9
GND on TOP (solid shape): 160.25,92.23 160.25,92.22 160.35,92.13 160.87,92.13 160.94,92.06 160.94,90.84 160.68,90.58 159.82,90.58 159.76,90.64 159.76,90.91 159.75,90.92 159.75,90.94 159.55,91.13 158.61,91.13 158.41,91.32 158.41,91.76 158.57,91.92 158.61,91.92 158.62,91.92 159.28,91.92 159.37,92.01 159.37,92.34 159.49,92.47 160.01,92.47
GND on TOP (solid shape): 181.83,94.47 181.83,91.25 181.61,91.02 180.94,91.02 179.61,92.36 179.26,92.36 179.24,92.36 179.22,92.37 179,92.46 178.79,92.37 178.77,92.36 178.75,92.36 178.11,92.36 177.72,92.75 177.72,95.27 177.85,95.41 180.9,95.41
GND on TOP (solid shape): 61.17,20.22 61.17,17.48 61.17,17.46 61.16,17.44 61.02,17.11 61.15,16.77 61.16,16.73 61.14,16.7 60.69,16.24 58.07,16.24 57.55,16.76 57.55,18.91 59.08,20.44 60.95,20.44
GND on TOP (solid shape): 153.76,96.7 153.78,96.69 153.8,96.68 154.06,96.57 154.33,96.68 154.35,96.69 154.37,96.7 154.56,96.7 155.18,96.08 155.32,96.08 155.76,95.64 156.05,95.64 156.17,95.52 156.17,95.03 156.15,95.01 155.99,95.01 155.99,95.01 155.62,95.01 155.57,94.96 151.85,94.96 151.78,95.02 151.78,96.1 152.38,96.7
GND on TOP (solid shape): 156.43,86.99 156.51,86.99 156.63,86.99 156.69,86.92 156.69,86.91 156.74,86.8 156.82,86.72 156.84,86.7 156.84,86.68 156.84,84.81 156.41,84.38 156.08,84.38 155.26,83.56 149.25,83.56 149.04,83.78 149.04,84.13 149.16,84.25 149.34,84.25 149.34,84.32 149.52,84.5 149.52,84.88 149.71,85.06 149.72,85.07 149.74,85.08 155.63,85.08 155.66,85.11 155.73,85.11 156.08,85.47 156.08,86.94 156.17,87.02 156.34,87.02
GND on TOP (solid shape): 162.05,96.68 162.07,96.68 162.08,96.66 162.37,96.38 163.55,96.38 164.5,95.44 164.5,94.76 164.84,94.42 164.84,92.4 165.21,92.03 165.22,92.01 165.22,92 165.23,91.85 165.3,91.73 165.31,91.72 165.31,91.68 165.27,91.64 163.85,91.64 163.52,91.97 163.52,92.5 163.46,92.56 163.46,93.1 163.39,93.18 163.39,94.82 163.23,94.98 160.9,94.98 160.72,95.15 158.82,95.15 158.48,95.49 157.59,95.49 157.25,95.83 157.25,96.29 157.49,96.52 158.79,96.52 158.94,96.68
GND on TOP (solid shape): 178.17,94.95 178.2,94.95 178.23,94.94 178.28,94.88 178.28,92.94 178.27,92.9 178.23,92.89 178.08,92.89 177.52,92.33 177.51,92.33 177.32,92.1 177.4,91.8 177.41,91.79 177.41,91.69 176.89,91.16 176.54,91.16 176.21,91.49 176.21,91.83 176.79,92.42 176.79,93.5 176.4,93.89 176.4,93.97 176.97,94.54 177.77,94.54 178.14,94.91 178.14,94.92 178.16,94.94
GND on TOP (solid shape): 119.37,54.99 119.37,54.54 119.59,54.32 120.39,54.32 120.41,54.35 120.45,54.35 120.45,54.38 120.83,54.77 123.36,54.77 123.68,54.45 123.68,52.66 122.92,51.9 117.59,51.9 117.07,52.42 117.07,52.82 117.45,52.82 117.45,52.76 117.45,52.69 117.47,52.63 117.49,52.57 117.52,52.52 117.56,52.47 117.6,52.42 117.65,52.38 117.71,52.35 117.76,52.32 117.82,52.3 117.89,52.29 117.95,52.28 118.01,52.29 118.07,52.3 118.13,52.32 118.19,52.35 118.24,52.38 118.29,52.42 118.34,52.47 118.37,52.52 118.4,52.57 118.43,52.63 118.44,52.69 118.45,52.76 118.45,52.82 118.44,52.88 118.43,52.94 118.4,53 118.37,53.06 118.34,53.11 118.29,53.15 118.24,53.19 118.19,53.23 118.13,53.26 118.07,53.28 118.01,53.29 117.95,53.29 117.89,53.29 117.82,53.28 117.76,53.26 117.71,53.23 117.65,53.19 117.6,53.15 117.56,53.11 117.52,53.06 117.49,53 117.47,52.94 117.45,52.88 117.45,52.82 117.07,52.82 117.07,53.78 116.78,54.07 116.05,54.07 115.55,53.57 113.42,53.57 113.2,53.78 113.2,55.1 113.45,55.34 119.02,55.34
GND on TOP (solid shape): 67.3,73.83 67.31,73.79 67.33,73.74 67.35,73.69 67.39,73.65 67.43,73.61 67.47,73.57 67.52,73.55 67.57,73.53 67.61,73.52 68.33,72.8 68.33,60.08 69.28,59.13 71.19,59.13 71.78,59.71 71.78,61.49 72.09,61.8 75.37,61.8 76.18,60.99 76.18,58.33 77.09,57.42 77.09,56.14 76.62,55.67 68.25,55.67 67.11,56.81 68.96,56.81 68.96,56.76 68.97,56.7 68.99,56.65 69.02,56.6 69.05,56.56 69.09,56.52 69.14,56.49 69.19,56.47 69.24,56.45 69.29,56.44 69.35,56.44 69.4,56.44 69.46,56.46 69.51,56.48 69.56,56.51 69.6,56.54 69.63,56.58 69.67,56.63 69.69,56.68 69.7,56.73 69.71,56.79 69.71,56.84 69.7,56.9 69.69,56.95 69.67,57 69.63,57.04 69.6,57.09 69.56,57.12 69.51,57.15 69.46,57.17 69.4,57.19 69.35,57.19 69.29,57.19 69.24,57.18 69.19,57.16 69.14,57.14 69.09,57.1 69.05,57.07 69.02,57.02 68.99,56.97 68.97,56.92 68.96,56.87 68.96,56.81 67.11,56.81 66.64,57.27 66.64,61.21 67.03,61.59 67.03,68.47 62.97,72.53 62.97,74.92 63.4,75.35 65.78,75.35
GND on TOP (solid shape): outline of 81 points within 91.18,50.99 112.62,70.42
GND on TOP (solid shape): outline of 81 points within 213.35,111.19 219.64,115.67
GND on TOP (solid shape): 166.1,107.17 170.56,107.17 171.86,105.88 174.05,105.88 175.4,104.53 175.4,102.69 175.98,102.12 179.68,102.12 180.48,101.32 180.48,100.96 180.2,100.67 174.98,100.67 174.87,100.56 171.77,100.56 170.77,101.56 170.77,101.58 170.63,101.9 170.31,102.04 170.29,102.05 170.24,102.1 168.6,102.1 168.26,102.45 168.26,103.25 167.46,104.05 166.31,104.05 166.11,104.25 165.87,104.25 165.84,104.25 165.82,104.27 165.65,104.42 165.41,104.44 165.21,104.47 165.02,104.4 164.99,104.39 164.96,104.39 164.84,104.44 164.71,104.44 164.44,104.45 164.24,104.27 164.22,104.25 164.2,104.25 163.23,104.25 163.09,104.38 163.09,107.55 163.14,107.6 165.68,107.6
GND on TOP (solid shape): 234.34,61.98 234.38,61.96 234.39,61.93 234.39,33.84 234.47,33.76 234.47,32.1 234.23,31.86 232.7,31.86 232.53,32.03 232.53,32.45 232.05,32.93 229.69,32.93 229.45,33.17 229.45,34.16 229.54,34.26 229.56,34.26 229.75,34.37 229.85,34.56 229.86,34.57 229.94,34.66 232.43,34.66 232.72,34.95 232.72,35.72 232.74,35.74 232.74,37.24 231.9,38.08 231.9,39.59 232.76,40.44 233.63,41.31 233.63,43.65 234.27,44.29 234.27,50.85 234.21,50.92 234.21,56.64 233.53,57.31 233.53,58.79 233.67,58.93 233.67,59.5 233.09,59.5 232.72,59.13 232.72,58.37 232.66,58.27 232.55,58.3 232.53,58.31 231.83,58.31 231.52,58.62 231.52,61.93 231.54,61.96 231.57,61.98
GND on TOP (solid shape): outline of 91 points within 50.89,38.82 54.38,48.67
GND on TOP (solid shape): outline of 99 points within 48.72,12.77 51.87,15.62
GND on TOP (solid shape): 234.3,109.91 234.3,106.49 234.23,106.39 234.11,106.42 232.49,106.75 231.97,105.18 231.96,105.08 231.88,105.03 230.12,105.03 229.75,105.4 229.75,107.39 229.78,107.46 229.87,107.48 230.04,107.49 230.19,107.58 230.23,107.59 230.26,107.57 230.91,107.83 230.28,108.12 230.24,108.1 230.21,108.12 230.05,108.22 229.87,108.23 229.78,108.25 229.75,108.33 229.75,109.29 231.03,110.58 233.63,110.58
GND on TOP (solid shape): 211.06,92.16 211.06,91.61 211.05,91.6 211.04,91.49 211.05,91.39 211.06,91.38 211.06,91.24 210.96,91.14 210.2,91.14 210.04,91.2 209.88,91.19 209.86,91.19 209.65,91.4 208.28,91.4 208.08,91.47 207.88,91.4 206.47,91.4 206.02,90.96 205.18,90.96 205.01,91.01 204.84,90.96 204.82,90.96 204.68,90.96 204.36,91.28 203.87,91.28 203.8,91.29 203.68,91.28 203.57,91.19 203.52,91.12 203.3,90.89 203.3,89.47 202.95,89.13 200.84,89.13 200.6,89.36 200.6,89.48 200.61,89.49 200.67,89.63 200.65,89.79 200.64,89.82 200.64,89.92 200.02,90.54 199.6,90.54 199.28,90.85 198.8,90.85 198.29,91.36 197.49,91.36 197.45,91.32 195.54,91.32 195.47,91.39 194.49,91.39 194.42,91.32 193.91,91.32 193.33,90.74 191.16,90.74 191.03,90.62 191.03,88 190.72,87.69 188.64,87.69 188.51,87.82 188.51,88.53 188.64,88.66 189.08,88.66 189.16,88.62 189.18,88.53 189.5,88.14 189.82,88.54 189.84,88.62 189.92,88.66 190.06,88.66 190.24,88.84 190.24,91.96 190.55,92.28 192.62,92.28 192.63,92.28 203.69,92.28 203.7,92.29 210.93,92.29
GND on TOP (solid shape): outline of 159 points within 147.15,20.5 156.77,31.08
GND on TOP (solid shape): outline of 167 points within 220.88,65.24 234.39,105.1
GND on TOP (solid shape): outline of 263 points within 0.41,82.28 123.35,115.69
GND on TOP (solid shape): 162.57,41.96 162.57,37.86 162.06,37.35 156.81,37.35 156.72,37.39 156.71,37.48 156.72,37.69 156.62,37.88 156.61,37.91 156.62,37.95 156.73,38.26 156.55,38.54 156.5,38.6 156.52,38.68 156.59,38.93 156.48,39.17 156.47,39.21 156.59,39.5 156.49,39.76 156.47,39.83 156.5,39.9 156.6,40.16 156.47,40.46 156.49,40.49 156.22,41.14 155.95,40.49 155.96,40.46 155.84,40.16 155.94,39.9 155.97,39.83 155.94,39.76 155.84,39.5 155.96,39.21 155.95,39.17 155.84,38.86 156.02,38.58 156.07,38.51 156.05,38.43 155.98,38.18 156.09,37.95 156.1,37.91 156.09,37.88 156,37.74 155.98,37.59 155.92,37.49 155.8,37.51 155.27,38.05 155.27,41.41 155.78,41.92 155.89,41.94 155.95,41.85 156.47,41.5 156.6,42.12 156.58,42.15 156.6,42.19 156.7,42.37 156.68,42.58 156.7,42.68 156.78,42.72 161.81,42.72
GND on TOP (solid shape): outline of 1835 points within 14.86,7.01 234.39,87.67
GND on BOTTOM (solid shape): 52.29,18.04 52.29,16.36 52.08,16.15 51.44,16.15 51.36,16.23 51.36,18.05 51.45,18.14 52.19,18.14
GND on BOTTOM (solid shape): 54.29,104.76 54.29,103.33 54.15,103.19 52,103.19 51.65,103.54 51.65,104.7 51.88,104.93 54.13,104.93
GND on BOTTOM (solid shape): 56.39,94.31 56.39,92.58 56.05,92.24 52.3,92.24 51.98,92.56 51.98,94.19 52.33,94.54 56.16,94.54
GND on BOTTOM (solid shape): 57.71,15.75 57.71,12.88 57.44,12.61 56.51,12.61 56.25,12.87 56.25,15.83 56.44,16.02 57.44,16.02
GND on BOTTOM (solid shape): 58.85,20.09 58.85,18.08 58.66,17.89 57.74,17.89 57.58,18.06 57.58,20.06 57.69,20.17 58.77,20.17
GND on BOTTOM (solid shape): 62.87,68.39 62.87,65.56 62.51,65.19 61.86,65.19 61.74,65.31 61.74,68.31 61.89,68.45 62.81,68.45
GND on BOTTOM (solid shape): 65.6,105.46 65.6,100.43 65.3,100.13 63.73,100.13 63.33,100.54 63.33,104.9 64,105.57 65.49,105.57
GND on BOTTOM (solid shape): 77.69,58.36 77.69,57.72 76.62,56.66 74.97,56.66 74.84,56.79 74.84,58.21 75.2,58.56 77.48,58.56
GND on BOTTOM (solid shape): 166.23,53.23 166.23,52.28 165.79,51.85 164.68,51.85 164.63,51.89 164.63,54 164.83,54.19 165.27,54.19
GND on BOTTOM (solid shape): 203.48,70.33 203.48,70.13 203.27,69.91 191,69.91 190.92,69.99 190.92,70.35 191.04,70.46 203.35,70.46
GND on BOTTOM (solid shape): 120.11,88.98 120.11,87.25 119.89,87.03 119.89,87.02 117.87,87.02 117.61,87.28 117.61,88.8 117.92,89.11 119.98,89.11
GND on BOTTOM (solid shape): 74.15,57.07 74.15,56.49 73.66,56 69.98,56 69.83,56.15 69.83,57.17 69.88,57.22 73.32,57.22 73.45,57.35 73.87,57.35
GND on BOTTOM (solid shape): 159.33,96.07 160.98,96.07 161.13,95.93 161.13,94.14 161.01,94.03 159.43,94.03 158.87,94.58 157.15,94.58 156.53,95.2 156.53,96.3 156.68,96.45 158.95,96.45
GND on BOTTOM (solid shape): 164.07,52.69 164.07,52.43 164,52.35 163.46,52.35 163.22,52.11 163.22,51 163.17,50.94 162.28,50.94 162.24,50.98 162.24,52.5 162.49,52.75 164.02,52.75
GND on BOTTOM (solid shape): 228.51,63.55 229.01,63.55 229.6,62.97 229.6,59.59 228.56,58.55 222.92,58.55 222.54,58.92 222.51,58.92 222.49,58.94 222.49,64.54 223.9,65.95 226.11,65.95
GND on BOTTOM (solid shape): 126.45,89.68 126.45,87.65 126.2,87.4 125.56,87.4 125.34,87.61 125.34,89.16 125.23,89.27 123.84,89.27 123.68,89.43 123.68,89.89 123.68,89.95 123.81,90.08 126.05,90.08
GND on BOTTOM (solid shape): 176.49,67.94 176.64,67.94 176.68,67.9 176.94,67.9 176.96,67.88 176.96,67.49 176.74,67.28 175.69,67.28 175.05,67.92 174.66,67.92 174.63,67.95 174.63,68.47 174.64,68.5 174.68,68.52 175.91,68.52
GND on BOTTOM (solid shape): 225.36,17.23 225.36,14.22 225.59,13.99 225.59,13.04 225.46,12.91 224.37,12.91 224.1,13.18 224.1,14.73 223.55,15.28 223.38,15.45 223.38,15.88 223.62,16.12 223.7,16.12 223.7,16.2 224.41,16.9 224.41,17.09 224.68,17.37 225.22,17.37
GND on BOTTOM (solid shape): 225.41,48.03 225.41,46.92 225.18,46.69 222.19,46.69 221.94,46.95 219.61,46.95 218.99,46.33 215.88,46.33 214.17,44.62 214.17,43.22 213.79,42.85 210.82,42.85 210.05,43.62 210.05,46.65 210.45,47.05 211.91,47.05 211.95,47.01 217.91,47.01 219.05,48.16 225.28,48.16
GND on BOTTOM (solid shape): 132.32,58.87 132.32,57.32 132.46,57.17 133.88,57.17 133.93,57.11 133.93,56.94 133.82,56.82 132.52,56.82 132.32,56.63 132.32,55.77 132.43,55.66 133.81,55.66 133.87,55.6 133.87,53.04 132.97,52.15 129.64,52.15 129.36,52.43 129.36,54.49 129.84,54.97 129.84,58.79 130.13,59.08 132.1,59.08
GND on BOTTOM (solid shape): 182.63,79.64 182.63,79 182.58,78.95 180.04,78.95 179.75,78.66 179.75,78.05 179.67,77.98 179.67,71.89 179.53,71.74 178.78,71.74 178.73,71.8 178.48,71.8 178.06,72.23 178.06,73.49 178.02,73.53 178.02,74.32 177.95,74.4 177.95,74.56 177.95,75.25 177.87,75.32 177.87,75.87 177.59,76.16 177.59,78.4 177.42,78.57 176.8,78.57 176.72,78.65 175.97,78.65 175.93,78.67 175.92,78.7 175.92,79.32 175.83,79.4 175.83,79.59 176.03,79.79 177.54,79.79 177.6,79.84 182.43,79.84
GND on BOTTOM (solid shape): 205.01,81.14 205.01,80.62 205.02,80.62 205.41,80.23 205.41,79.86 205.26,79.71 204.39,79.71 204.25,79.57 204.25,79.57 204.14,79.46 204.14,78.59 203.87,78.32 194.7,78.32 194.2,78.82 192.14,78.82 191.69,79.27 191.69,80.67 191.86,80.85 192.23,80.85 192.26,80.81 193.32,80.81 194.29,79.84 195.32,79.84 195.55,80.07 195.55,80.13 195.78,80.35 196.18,80.35 196.21,80.33 197.08,80.33 197.08,80.32 199.77,80.32 200.35,80.9 200.37,80.9 200.53,80.74 200.53,80.05 200.67,79.91 203.52,79.91 203.74,80.13 203.74,80.87 204.19,81.32 204.83,81.32
GND on BOTTOM (solid shape): 143.83,56.99 147.76,56.99 148.38,56.37 148.38,55.16 148.3,55.09 147.52,55.09 147.4,55.21 147.39,55.23 147.39,55.24 147.21,55.63 146.79,55.6 146.7,55.5 146.65,55.37 146.63,55.34 146.6,55.33 140.72,55.33 140.38,55.67 140.38,57.98 140.62,58.22 142.6,58.22
GND on BOTTOM (solid shape): 201.85,99.3 209.49,99.3 210.35,100.16 214.32,100.16 215.12,99.36 215.12,99.21 215.19,99.18 215.22,99.11 215.39,98.81 215.74,98.78 215.77,98.78 215.79,98.77 216.77,97.79 220.53,97.79 220.59,97.73 220.59,96.7 220.51,96.62 216.61,96.62 215.23,98 192.9,98 192.77,98.13 192.77,99.53 193.36,100.12 193.62,100.12 194.89,101.39 199.76,101.39
GND on BOTTOM (solid shape): 185.3,85.41 185.3,84.07 185.22,83.99 185.2,83.98 185.05,83.97 184.93,83.9 184.44,83.9 184.23,83.97 184.02,83.9 183.53,83.9 183.4,83.97 183.25,83.97 183.23,83.97 183.21,83.98 183.03,84.15 183.03,85.02 183.07,85.06 184.21,85.06 184.7,85.54 184.7,85.57 184.71,85.6 184.75,85.62 185.09,85.62
GND on BOTTOM (solid shape): 223.39,70.09 223.39,69.92 223.28,69.8 219.87,69.8 219.51,69.44 219.51,69.32 219.47,69.23 219.38,69.22 219.21,69.23 219.06,69.15 218.84,69.15 218.7,69.23 218.54,69.23 218.35,69.1 218.29,68.88 218.29,68.86 218.29,68.84 217.92,68.48 215.42,68.48 214.97,68.93 214.97,69.27 215.45,69.75 215.45,70.15 215.46,70.18 215.5,70.2 215.69,70.2 215.87,70.02 219.58,70.02 219.87,70.32 223.17,70.32
GND on BOTTOM (solid shape): 230.95,28.54 230.95,28.33 230.91,28.29 230.91,21.47 230.98,21.4 230.98,21.33 231.23,21.07 231.23,16.8 231.01,16.58 230.57,16.58 230.43,16.71 230.42,16.73 230.42,17.01 230.39,17.03 230.39,17.79 230.42,17.81 230.42,18.21 230.22,18.41 230.22,19.15 229.78,19.59 229.78,20.78 229.65,20.9 229.65,20.99 229.57,20.99 229.47,21.08 229.47,22.97 229.16,23.29 229.16,24.05 229.24,24.13 229.24,25.56 230.16,26.48 230.16,26.89 230.46,27.19 230.52,27.19 230.52,27.27 230.54,27.3 230.57,27.32 230.58,27.32 230.58,27.94 230.52,28 230.52,28.05 230.48,28.05 230.29,28.24 228.43,28.24 228.02,28.65 228.02,29.28 228.28,29.54 228.28,29.55 228.31,29.59 229.9,29.59
GND on BOTTOM (solid shape): 169.09,91.03 169.09,89.56 169.27,89.38 169.27,88.1 169.3,88.07 169.3,88.05 169.5,87.85 169.5,85.86 169.17,85.53 169.17,82.27 168.9,82 167.7,82 167.3,82.4 167.3,85.77 167.45,85.92 167.47,85.92 167.64,85.97 167.76,86.11 167.76,86.11 167.91,86.26 167.91,86.38 168.21,86.68 168.22,86.68 168.37,86.83 168.4,87.04 168.4,87.06 168.4,87.07 168.45,87.26 168.38,87.44 168.38,88.88 168.35,88.91 168.34,88.93 168.34,88.98 167.86,89.47 167.86,91.59 168.09,91.82 168.3,91.82
GND on BOTTOM (solid shape): 135.4,84.26 139.94,84.26 140.29,83.91 140.29,81.71 139.67,81.08 135.85,81.08 135.51,81.41 135.51,81.81 135.44,81.89 135.44,82.1 135.28,82.26 132.31,82.26 131.93,82.64 123.64,82.64 122.45,81.45 121.76,81.45 121.26,81.95 121.26,83.21 121.65,83.61 122.09,83.61 122.11,83.59 123.16,83.59 125.64,86.07 126.17,86.07 126.17,86.01 126.18,85.96 126.2,85.91 126.23,85.86 126.26,85.82 126.3,85.78 126.35,85.75 126.4,85.72 126.45,85.7 126.5,85.69 126.56,85.69 126.61,85.7 126.67,85.71 126.72,85.73 126.77,85.76 126.81,85.8 126.85,85.84 126.88,85.88 126.9,85.93 126.92,85.99 126.92,86.04 126.92,86.1 126.92,86.15 126.9,86.2 126.88,86.25 126.85,86.3 126.81,86.34 126.77,86.38 126.72,86.41 126.67,86.43 126.61,86.44 126.56,86.45 126.5,86.45 126.45,86.44 126.4,86.42 126.35,86.39 126.3,86.36 126.26,86.32 126.23,86.28 126.2,86.23 126.18,86.18 126.17,86.12 126.17,86.07 125.64,86.07 126.89,87.31 126.89,88.47 126.86,88.49 126.86,88.52 127.38,89.04 130.63,89.04
GND on BOTTOM (solid shape): 203.24,87.53 204.67,87.53 204.75,87.45 204.75,87.44 204.86,87.25 205.05,87.15 205.06,87.14 205.8,86.4 206.96,86.4 207,86.38 207.01,86.35 207.01,85.72 207.82,85.72 207.85,85.69 208.56,85.69 208.56,85.89 208.62,85.99 208.73,85.96 208.79,85.91 209.43,85.91 209.59,85.75 209.59,84.84 209.57,84.81 209.54,84.79 208.82,84.79 208.56,85.05 208.56,85.49 207.85,85.49 207.85,84.76 207.84,84.72 207.8,84.71 207.07,84.71 207.01,84.71 207.01,84.71 206.77,84.46 206.23,84.46 205.54,85.15 203.81,85.15 203.76,85.1 203.76,84.86 203.65,84.75 203.25,84.75 203.16,84.76 202.76,85.16 202.76,87.35 202.74,87.37 202.74,87.43 202.86,87.54 203.23,87.54
GND on BOTTOM (solid shape): 189.54,69.08 189.54,68.33 189.43,68.22 189.41,68.21 189.39,68.2 188.65,68.2 188.62,68.18 188.36,68.18 188.17,67.98 187.18,67.98 186.97,68.06 186.76,67.98 186.27,67.98 186.06,68.06 185.85,67.98 185.65,67.98 185.47,68.16 184.88,68.16 184.85,68.12 184.51,68.12 184.37,67.98 184.19,67.98 183.98,68.06 183.77,67.98 183.27,67.98 183.06,68.06 182.85,67.98 182.37,67.98 182.16,68.06 181.95,67.98 181.44,67.98 181.23,68.06 181.02,67.98 180.1,67.98 180.01,68.08 180.01,68.49 180.1,68.58 180.24,68.58 180.25,68.58 187.74,68.58 188.17,69 188.25,69 188.25,69.08 188.34,69.17 189.45,69.17
GND on BOTTOM (solid shape): outline of 99 points within 125.62,67.89 130.3,74.2
GND on BOTTOM (solid shape): 199.47,87.13 199.52,87.13 199.58,87.08 199.64,87.06 199.81,87.05 199.97,87.13 200.1,87.13 200.15,87.08 200.15,86.23 199.96,86.04 198.8,86.04 198.79,86.06 198.76,86.14 198.8,86.22 198.92,86.65 198.49,86.79 198.46,86.78 198.43,86.8 198.21,87.02 198.21,87.48 197.46,87.48 197.43,87.43 197.37,87.44 196.82,87.24 197.31,86.92 197.41,86.92 197.46,86.83 197.46,86.77 197.26,86.58 197.26,86.56 197.25,86.56 197.06,86.37 196.52,86.37 196.22,86.07 196.22,83.62 195.55,82.95 195.55,82.9 195.54,82.86 195.5,82.85 194.16,82.85 194.05,82.96 194.05,86.12 194.52,86.59 194.52,86.59 195.67,87.74 196.02,87.74 196.08,87.8 198.8,87.8
GND on BOTTOM (solid shape): 174.84,100.34 179.32,100.34 180.23,99.43 185.19,99.43 185.99,98.64 185.99,98.21 186.53,97.66 186.53,96.51 186.53,96.51 186.53,95.51 186.53,95.51 186.53,95.2 186.12,94.79 186.12,92.53 186.7,91.95 186.7,90.31 186.18,89.79 186.18,89.28 186.17,89.25 186.13,89.23 185.88,89.23 185.62,88.97 185.62,87.56 185.63,87.55 185.65,87.51 185.63,87.47 185.55,87.38 185.56,87.37 185.56,86.78 185.52,86.51 185.69,86.3 185.7,86.3 185.8,86.2 185.8,85.02 185.51,84.73 185.51,84.69 185.42,84.6 185.42,84.01 185.36,83.94 185.3,83.94 185.29,83.95 185.14,83.98 185,83.95 184.99,83.94 184.79,83.94 184.56,84.17 184.56,85.56 184.64,85.64 184.64,86.1 184.65,86.12 185.04,86.51 185.04,91.16 185.04,91.19 185.18,91.33 185.21,91.5 185.21,91.51 185.23,91.55 185.28,91.84 185.07,92.06 185.06,92.06 185.04,92.09 185.04,97.53 185.04,97.53 185.04,97.93 184.69,98.28 180.06,98.28 179.43,98.91 171.47,98.91 171.07,99.31 171.07,100.29 171.07,101.26 171.3,101.49 173.69,101.49
GND on BOTTOM (solid shape): outline of 123 points within 221.94,21.55 226.23,31.81
GND on BOTTOM (solid shape): 126.17,48 133.34,48 133.9,47.88 134.45,47.71 134.69,47.48 135.1,47.48 135.82,47.16 136.51,46.78 139.6,43.69 140.14,42.54 140.5,41.33 140.6,40.81 140.66,40.29 140.66,21.89 144.27,18.29 148.31,18.29 148.38,18.23 149.15,18.23 149.76,18.23 150.21,17.78 150.21,8.81 151.3,7.72 199.58,7.72 200.03,8.17 203.41,8.17 204.21,7.37 217.54,7.37 217.81,7.64 225.92,7.64 226.38,7.18 226.4,7.07 226.31,7.01 149.71,7.01 149.67,7.02 149.66,7.06 149.66,17.51 140.11,17.51 140.07,17.52 140.06,17.56 140.06,39.1 137.59,45.04 131.65,47.51 123.82,47.51 123.73,47.57 123.75,47.68 124.27,48.19 125.98,48.19
GND on BOTTOM (solid shape): outline of 187 points within 215.85,12.06 222.05,15.98
GND on BOTTOM (solid shape): outline of 199 points within 37.91,34.52 60.35,50.49
GND on BOTTOM (solid shape): outline of 306 points within 197.21,7.01 234.4,115.69
GND on BOTTOM (solid shape): outline of 2319 points within 0.41,7.01 182.36,115.69
GND on BOTTOM (solid shape): outline of 2724 points within 185.54,52.16 210.71,58.28
GND on GND02 (solid shape): outline of 89873 points within 0.41,7.01 234.39,115.69
GND on ART03 (solid shape): 78.03,76.24 78.03,75.75 77.91,75.63 69.01,75.63 68.6,76.04 68.6,76.33 68.76,76.48 77.79,76.48
GND on ART03 (solid shape): 104.37,95.08 104.37,94.28 103.47,93.37 97.4,93.37 96.94,93.84 96.94,94.98 97.27,95.31 104.14,95.31
GND on ART03 (solid shape): 226.54,104.45 226.54,101.51 226.08,101.05 222.26,101.05 221.29,102.02 221.29,103.88 222.17,104.76 226.23,104.76
GND on ART03 (solid shape): 99.79,79.13 99.79,77.52 99.3,77.03 98.13,77.03 97.5,76.4 97.5,74.7 96.85,74.05 93.91,74.05 93.53,74.43 93.53,75.46 97.47,79.4 99.52,79.4
GND on ART03 (solid shape): 51.74,27.84 51.77,27.83 51.79,27.79 51.79,21.75 51.62,21.58 51.58,21.57 51.55,21.58 51.25,21.88 49.56,21.88 48.98,22.46 48.98,26.97 49.85,27.84
GND on ART03 (solid shape): 201.33,85.12 203.63,85.12 203.72,85.03 203.72,84.85 203.61,84.74 203.34,84.74 202.78,84.19 202.78,83.07 202.59,82.88 201.56,82.88 201.14,82.46 201.14,82.26 201.01,82.13 200.7,82.13 200.41,82.42 200.41,84.85 200.35,84.9 200.35,85.13 200.44,85.22 201.23,85.22
GND on ART03 (solid shape): 198.75,90.77 198.75,89.37 198.48,89.1 193.73,89.1 192.69,88.05 192.69,86.8 193.65,85.84 194.94,85.84 195.52,85.27 195.52,83.05 195.27,82.8 191.36,82.8 191.19,82.97 191.19,85.73 190.74,86.18 190.74,86.26 190.61,86.39 190.61,87.97 189.87,88.71 189.87,90.68 190.82,91.62 197.9,91.62
GND on ART03 (solid shape): 49.22,15.59 49.5,15.59 49.6,15.54 49.7,15.52 49.72,15.52 49.97,15.27 49.97,14.59 49.73,14.36 49.73,13.78 51.45,12.06 53.53,12.06 54.05,11.54 54.05,11.09 53.64,10.68 48.75,10.68 48.74,10.67 47.74,10.67 47.18,10.11 45.99,10.11 45.72,10.38 45.72,15.67 46.88,16.83 47.99,16.83
GND on ART03 (solid shape): 198.17,85.38 198.17,82.87 198.04,82.74 198.02,82.73 198.01,82.73 197.93,82.74 197.85,82.72 197.14,82.72 197.14,82.72 197.04,82.74 196.94,82.72 196.93,82.72 196.13,82.72 196.12,82.72 195.92,82.92 195.92,85.58 195.92,85.58 195.92,85.65 195.3,86.26 195.23,86.26 195.16,86.34 194.83,86.34 194.73,86.44 194.73,86.67 194.82,86.76 196.79,86.76

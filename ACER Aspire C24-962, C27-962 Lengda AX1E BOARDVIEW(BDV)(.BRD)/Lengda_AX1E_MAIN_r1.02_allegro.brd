# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
OUT_CLK-: length 3.4
  TOP w0.109: C374.2 58.57,81.27 58.57,82.68 58.68,82.79 R201.2 59.06,83.62 FIL8.1
OUT_D0+: length 3.3
  TOP w0.109: FIL7.4 55.34,83.67 R251.2 55.72,82.79 55.83,82.68 55.83,81.26 C371.2
OUT_D0-: length 3.4
  TOP w0.109: FIL7.1 56.54,83.62 R249.2 56.16,82.79 56.05,82.68 56.05,81.27 C372.2
OUT_D1+: length 3.3
  TOP w0.109: FIL6.4 52.88,82.87 R254.2 53.19,82.79 53.29,82.68 53.29,81.26 C369.2
OUT_D1-: length 3.4
  TOP w0.109: FIL6.1 53.88,82.91 R253.2 53.62,82.79 53.51,82.68 53.51,81.27 C370.2
OUT_D2+: length 3.4
  TOP w0.109: FIL5.4 50.39,82.91 R257.2 50.69,82.79 50.8,82.68 50.8,81.29 C367.2
OUT_D2-: length 3.4
  TOP w0.109: FIL5.1 51.39,82.94 R255.2 51.13,82.79 51.02,82.68 51.02,81.23 C368.2
OVERT: length 232
  ART06 w0.102: v1(39.93,82.33) 42.2,82.33 42.96,81.57 42.96,81.01 41.52,79.57 41.52,77.93 42.68,76.77 42.68,72.73 45.42,69.99 45.42,69.61 45.94,69.09 46.64,69.09 48.71,67.02 50.59,67.02 51.27,66.34 51.27,65.1 51.69,64.67 51.69,61.12 52.44,60.36 58.87,60.36 60.63,58.6 72.43,58.6 72.75,58.93 75.9,58.93 76.93,57.89 92.39,57.89 94.49,59.99 101.05,59.99 103.47,57.56 107.32,57.56 107.87,57.02 112.8,57.02 113.31,57.52 114.26,57.52 114.9,58.16 120.77,58.16 121.56,58.94 122.74,58.94 123.44,58.24 125.76,58.24 128.07,55.93 135.92,55.93 138.76,53.09 142.38,53.09 149.04,46.43 150.41,46.43 150.83,46.01 153.59,46.01 v1(154.27,46.69)
  BOTTOM w0.075: 221.33,58.35 220.17,57.18 220.17,54.5 219.2,53.53
  BOTTOM w0.102: 219.2,53.53 218.17,52.5 217.3,52.5 215.07,50.27 207.84,50.27 206.29,48.72 189.44,48.72 187.89,50.27 174.83,50.27 171.71,47.14 164.01,47.14 162.16,45.29 162.08,45.29 162.08,45.28 157.84,45.28 157.24,45.89 156.31,45.89 155.52,46.68 154.29,46.68 v1(154.27,46.69) ; v1(39.93,82.33) 39.93,82.33 R15.2 ; CN14.46 228.41,54.6 224.88,58.13 222.76,58.13 222.44,58.45 221.44,58.45 221.33,58.35
OVPA: length 59.4
  ART06 w0.305: v1(68.08,28.15) 62.03,34.21 30.78,34.21 24.49,40.49 24.49,48.22 v1(23.35,49.37)
  BOTTOM w0.305: U37.7 23.62,49.1 v1(23.35,49.37)
PCBBEEP: length 3.8
  TOP w0.102: R395.1 C478.2 34.1,89.2 C479.1
PCH_GPU_RST1: length 83.9
  TOP w0.075: U1.DV33 168.87,70.47 167.6,69.2 v1(167.47,69.32) 167.34,69.2 R72.1
  TOP w0.102: U32.1 232.05,57.8 231.26,58.6 231.26,66.16 v1(229.95,67.47)
  ART06 w0.102: v1(167.47,69.32) 167.75,69.32 169.19,67.89 171.11,67.89 171.17,67.95 174.9,67.95 175.19,68.24 179.49,68.24 179.78,67.95 179.78,67.72 180.21,67.29 181.37,67.29 181.96,66.71 182.42,66.71 182.62,66.91 182.62,68.48 182.91,68.76 184.37,68.76 184.7,69.1 186.65,69.1 187.06,68.69 209.68,68.69 210.52,69.53 227.89,69.53 v1(229.95,67.47)
PCH_IST_TP_0: length 1.8
  TOP w0.076: U1.CW33 178.67,70.6 178.67,71.02 179.06,71.41 v1(179.14,71.41)
  BOTTOM w0.075: TP22.1 179.11,71.07 179.11,71.38 v1(179.14,71.41)
PCH_IST_TP_1: length 2.7
  TOP w0.076: U1.CY32 178.04,71.58 177.9,71.71 177.43,71.71 v1(176.93,72.22)
  BOTTOM w0.127: TP23.1 176.7,72 v1(176.93,72.22)
PCH_NVME_RST: length 85.7
  TOP w0.076: v1(167.31,68.67) 167.31,68.72 167.36,68.76 168.62,68.76 168.8,68.84 169.41,68.84 U1.DU36
  TOP w0.102: R526.2 93.82,60.25 94.2,59.88 v1(94.2,58.95)
  ART03 w0.102: v1(167.31,68.67) 167.08,68.9 165.15,68.9 164.76,68.51 164.32,68.51 163.99,68.84 160.62,68.84 159.94,68.16 158.97,68.16 158.48,68.64 156.23,68.64 156.11,68.77 154.77,68.77 154.57,68.57 150.98,68.57 149.26,66.84 140.69,66.84 139.87,67.67 139.25,67.67 135.06,63.47 130.25,63.47 127.64,60.85 124.54,60.85 124.31,60.63 122.46,60.63 120.21,58.38 115.07,58.38 114.65,57.96 112.85,57.96 112.46,57.57 108.3,57.57 107.76,58.1 106.14,58.1 105.3,58.94 101.6,58.94 101.37,58.71 99.51,58.71 99.45,58.77 94.38,58.77 v1(94.2,58.95)
PCH_PLT_RST#: length 64.9
  TOP w0.075: 178.46,52.94 178.46,54.45 177.83,55.08 177.83,56.78 179.59,58.54 180.18,58.54 180.27,58.63 180.29,58.63 181.95,60.29 181.95,60.31 182.03,60.39 U1.CM49
  TOP w0.102: 152.32,60.18 152.44,60.18 152.62,60 153.52,60 R830.1 153.91,59.62 153.91,57.29 156.31,54.88 161.33,54.88 v1(161.58,54.64) ; 152.32,60.18 152.09,60.18 ; 152.32,60.18 152.22,60.08 152.22,60.05 ; U5.2 152.09,60.18 ; 152.09,60.18 152.22,60.05 ; v1(156.45,47.2) 157.09,47.83 160.33,47.83 160.95,47.22 176.37,47.22 178.46,49.31 178.46,52.94 ; U5.1 152.14,59.53 152.22,59.62 152.22,60.05
  ART03 w0.102: v1(161.58,54.64) 161.52,54.59 161.52,54.46 159.73,52.67 158.22,52.67 157.11,51.56 157.11,50.47 156.45,49.81 v1(156.45,47.2)
PCH_POPIRCOMP: length 3.9
  TOP w0.075: R85.1 168.57,87.48 168.57,86.9 169.22,86.26
  TOP w0.076: 169.22,86.26 169.22,85.93 169.36,85.78 169.36,85.19 U1.DU3
PCH_PWROK: length 144.8
  TOP w0.076: U1.DN47 171.15,63.34 171.15,61.95 170.8,61.6 169,61.6 168.58,61.18 168.03,61.18 167.35,61.87
  TOP w0.124: R323.2 166.15,61.38 166.56,61.8 v1(166.56,62.07) 166.77,61.87 167.35,61.87
  ART03 w0.102: v1(166.56,62.07) 166.32,62.07 164.6,60.35 155.79,60.35 152.81,63.33 135.87,63.33 134.76,62.22 130.25,62.22 128.47,60.45 124.7,60.45 124.48,60.22 122.63,60.22 120.35,57.94 115.23,57.94 114.77,57.48 113.04,57.48 112.65,57.09 107.76,57.09 107.29,57.56 105.85,57.56 105.24,58.17 99.18,58.17 98.99,58.36 81.68,58.36 79.43,60.61 78.75,60.61 78.16,60.02 74.71,60.02 73.42,61.31 55.83,61.31 55.14,62 43.14,62 41.69,63.45 v1(41.69,64.57)
  BOTTOM w0.076: v1(166.56,62.07) 166.53,62.07 165.75,61.3 R94.1
  BOTTOM w0.109: v1(41.69,64.57) 41.23,64.57 41.12,64.45 U9.35
PCH_SLP_LAN#: length 8.3
  TOP w0.076: U1.DN48 171.76,62.77 171.76,61.87 171.03,61.14 169.35,61.14
  TOP w0.102: 169.35,61.14 168.36,60.15 167.93,60.15 TP7.1 167.17,60.1 166.69,60.58 165.62,60.58 R387.1
PCH_SLP_S5#: length 8.9
  TOP w0.076: U1.DF45 175.89,64.33 176.09,64.13 176.09,63.43 175.98,63.22 175.98,63.01 176.01,62.79 176.01,61.3 174.77,60.05 174.44,60.05 172.96,58.58 172.96,58.42
  TOP w0.102: R1389.1 172.96,57.96 172.96,58.42
PCH_SLP_SA#: length 4.1
  TOP w0.075: U1.DH47 173.93,63.54 174.24,63.23 174.24,61.77 v1(174.31,61.7)
  BOTTOM w0.203: R383.1 173.81,62.2 v1(174.31,61.7)
PCH_SLP_WLAN#: length 8.4
  TOP w0.075: 171.78,56.64 171.78,56.9 TP8.1 172.18,57.31 172.18,58.09 174.34,60.25
  TOP w0.076: U1.DE49 175.77,61.33 174.68,60.25 174.34,60.25
  TOP w0.102: 171.78,56.64 R384.1
PCH_SYSRST#: length 132.2
  TOP w0.076: U1.DK19 v1(172.86,76.71)
  TOP w0.102: R92.2 163.15,76.05 C6140.2 163.09,77.32 162.74,77.32 v1(162.52,77.11) ; v1(61.03,65.62) 61.03,66.26 60.33,66.96 60.33,71.4 v1(60.47,71.53)
  ART03 w0.102: v1(172.86,76.71) 172.47,76.32 170.6,76.32 170.32,76.6 165.45,76.6 165.3,76.75 162.88,76.75 v1(162.52,77.11) 162.31,77.11 161.68,77.74 159.99,77.74 158.95,76.69 158.32,76.69 156.26,74.63 154.68,74.63 154.3,75.01 148.77,75.01 147.37,73.6 143.56,73.6 142.25,72.29 137.41,72.29 133.11,67.99 127.09,67.99 123.49,64.39 118.4,64.39 117.34,63.33 107.73,63.33 107.03,62.63 100.88,62.63 100.51,62.26 81.58,62.26 81.18,62.66 78.27,62.66 76.45,64.48 74.26,64.48 73.95,64.17 65.23,64.17 64.22,65.18 63.03,65.18 62.87,65.02 61.63,65.02 v1(61.03,65.62)
  BOTTOM w0.102: R79.2 60.18,71.82 v1(60.47,71.53)
PCIE_GPU_WAKE#: length 227.2
  TOP w0.102: v1(54.87,57.83) 53.76,58.94 53.76,60.84 51.78,62.82 R441.2 ; v1(159.95,55.9) 160.02,55.9 160.4,56.28 160.4,58.85 160.93,59.38 162.6,59.38 R439.2
  ART03 w0.102: v1(54.87,57.83) 54.87,57.55 55.76,56.67 64.13,56.67 66.04,58.57 75.68,58.57 76.61,57.63 79.05,57.63 81.08,55.6 89.27,55.6 89.75,56.07 95.19,56.07 95.65,56.53 97.79,56.53 98.15,56.17 104.32,56.17 106.11,54.39 110.7,54.39 111.47,55.15 123.48,55.15 124.4,56.08 125.75,56.08 127.85,58.17 132.33,58.17 133.26,59.1 136.88,59.1 137.83,60.05 145.07,60.05 145.69,59.42 149.85,59.42 150.23,59.04 151.59,59.04 154.47,56.16 155.43,56.16 156.28,57.02 158.22,57.02 159.03,56.21 159.69,56.21 159.95,55.95 v1(159.95,55.9) 159.95,55.65 158.37,54.06 156.94,54.06 154.97,52.09 154.97,49.17 153.42,47.62 153.42,45.96 153.93,45.46 153.93,39.7 152.55,38.32 v1(150.72,38.32)
  BOTTOM w0.102: D38.P 214.89,34.67 214.59,34.97 208.21,34.97 206.05,37.13 190.08,37.13 188.14,35.19 182.47,35.19 180.26,32.98 155.17,32.98 150.72,37.43 v1(150.72,38.32)
PCIE_RCOMPN: length 4.1
  TOP w0.076: U1.DN1 171.81,85.85 170.13,87.53 170.13,88.43 R67.2
PCIE_RCOMPP: length 4
  TOP w0.076: R67.1 169.57,87.72 170.76,86.53 170.76,86.05 171.01,85.8 171.28,85.8 171.49,85.6 171.49,85.46 U1.DN3
PCIE_RX_DN<10>: length 156.6
  TOP w0.076: U1.CE6 v1(186.06,83.65)
  ART03 w0.075: 185.55,97.57 185.55,97.55 185.57,97.54 185.57,93.18 185.44,93.05 185.44,87.66 186.36,86.73 186.36,85.35 186.87,84.84 186.87,84.36 186.5,83.99 186.5,83.45 186.42,83.37 186.35,83.37 v1(186.06,83.65)
  ART03 w0.087: v1(81.96,76.26) 81.68,76.55 81.68,76.65 81.84,76.81 85.02,76.81 87.22,74.62 91.48,74.62 103.22,86.36 103.22,89.87 117.63,104.28 123.83,104.28 124.53,104.98 128.18,104.98 131.13,102.03 140.01,102.03 140.88,102.9 140.88,103.77 142.11,105 149.89,105 150.24,105.35 163.83,105.35 164.22,104.96 165.83,104.96 166.01,104.79 174.26,104.79 175.02,104.04 182.25,104.04 185.55,100.74 185.55,97.57
  BOTTOM w0.109: C422.1 78.59,67.65 80.72,67.65 81.92,68.84 81.92,75.43 81.58,75.77 81.58,75.88 v1(81.96,76.26)
PCIE_RX_DN_5_GPU: length 147.4
  TOP w0.076: U1.DA6 v1(177.82,83.65)
  ART03 w0.075: v1(177.82,83.65) 177.57,83.4 177.41,83.4 177.28,83.27 177.28,81.82 177.68,81.41 177.68,79.88 180.27,77.29 180.27,70.35 179.8,69.88 179.8,65.23 178.89,64.31 178.89,61.89 178.31,61.31 178.31,60.73 175.17,57.58 175.16,57.58 174.73,57.15 174.73,56.78 174.55,56.6 174.53,56.6 174.52,56.59
  ART03 w0.087: v1(156.22,39.51) 156.47,39.25 158.21,39.25 162.13,43.16 162.13,46.2 164.86,48.93 166.87,48.93 174.52,56.59
  BOTTOM w0.109: CN14.44 230.81,53.8 230.52,53.51 228.73,53.51 225.82,50.6 225.82,42.66 225.56,42.4 216.3,42.4 214.72,40.83 210.18,40.83 208.37,42.64 187.1,42.64 187.1,42.64 186.92,42.64 185.11,40.83 179.62,40.83 177.45,38.66 157.99,38.66 157.31,39.33 156.39,39.33 v1(156.22,39.51)
PCIE_RX_DN_6_GPU: length 150.4
  TOP w0.076: U1.CY7 v1(178.74,83.02)
  ART03 w0.075: v1(178.74,83.02) 178.51,83.25 178.43,83.25 178.34,83.16 178.34,82.31 178.78,81.87 178.78,80.03 181.45,77.36 181.45,70.44 180.83,69.83 180.83,64.53 179.56,63.25 179.56,61.61 179.03,61.08 179.03,60.56 175.44,56.98 175.44,56.35 175.12,56.02 175.12,56 175.11,55.99
  ART03 w0.087: 175.11,55.99 167.11,47.99 165.14,47.99 163.01,45.86 163.01,41.58 158.19,36.77 155.99,36.77 155.63,37.12 155.63,37.75 155.96,38.08 156.22,38.08 v1(156.36,38.21)
  BOTTOM w0.109: CN14.38 228.99,51.4 226.53,48.93 226.53,42.33 225.87,41.66 216.64,41.66 215.1,40.12 209.89,40.12 208.12,41.89 187.18,41.89 185.4,40.12 179.91,40.12 177.65,37.85 157.78,37.85 157.41,38.21 v1(156.36,38.21)
PCIE_RX_DN_7_GPU: length 112.6
  TOP w0.076: U1.CV7 v1(179.65,83.02)
  ART03 w0.075: v1(179.65,83.02) 179.41,83.26 179.31,83.26 179.26,83.21 179.26,81.95 179.33,81.87 179.4,81.87 179.49,81.79 179.49,81.64 179.42,81.57 179.33,81.57 179.26,81.5 179.26,81.23 179.76,80.72 179.76,80.19 181.76,78.19 181.76,64.86 180.26,63.36 180.26,60.94 176.09,56.77 176.09,55.87 175.69,55.47 175.69,55.44 175.67,55.43
  ART03 w0.087: v1(165.73,46.71) 165.65,46.71 165.31,47.05 165.31,47.11 165.5,47.3 167.54,47.3 175.67,55.43
  BOTTOM w0.075: 221.27,55.42 221.27,55.43 221.34,55.49
  BOTTOM w0.109: v1(165.73,46.71) 165.51,46.49 165.51,46.36 165.6,46.27 171.54,46.27 175.04,49.77 187.51,49.77 189.41,47.86 206.26,47.86 208.16,49.77 215.31,49.77 217.42,51.87 218.28,51.87 219.77,53.36 220.89,53.36 221.27,53.74 221.27,55.42 ; 221.34,55.49 222.01,56.17 222.55,56.17 222.98,56.6 CN14.51
PCIE_RX_DN_8_GPU: length 117.7
  TOP w0.076: U1.CT6 v1(180.57,83.65)
  ART03 w0.075: 176.19,54.91 176.2,54.93 176.23,54.93 176.76,55.46 176.76,56.76 182.69,62.7 182.69,64.37 182.54,64.52 182.54,70.06 182.88,70.4 182.88,77.66 180.02,80.52 180.02,83.27 180.16,83.41 180.33,83.41 v1(180.57,83.65)
  ART03 w0.087: 176.19,54.91 167.34,46.07 163.9,46.07 163.52,45.69 163.52,45.19 v1(163.49,45.16)
  BOTTOM w0.109: v1(163.49,45.16) 163.49,45.78 163.84,46.13 164.66,46.13 165.31,45.49 172.02,45.49 175.59,49.06 186.87,49.06 188.93,47 206.69,47 208.75,49.06 215.75,49.06 217.79,51.09 218.53,51.09 219.98,52.54 221.52,52.54 222.03,53.05 222.03,53.7 222.3,53.96 222.65,53.96 222.88,54.2 CN14.45
PCIE_RX_DN_9_WIFI: length 70.1
  TOP w0.076: U1.CG7 v1(185.14,83.02)
  TOP w0.109: v1(142.4,103.92) 142.63,103.69 142.78,103.69 142.97,103.5 142.97,102.26 142,101.3 142,98.39 141.8,98.18 141.65,98.18 141.58,98.11 CN22.43
  ART03 w0.075: v1(185.14,83.02) 185.35,83.02 185.69,83.36 185.69,85.48 185.22,85.95 185.22,86.99 184.86,87.35 184.86,89.48 184.18,90.15 184.18,97.54 184.2,97.55 184.2,97.57
  ART03 w0.087: v1(142.4,103.92) 143.07,103.92 143.13,103.97 150.28,103.97 150.7,104.39 163.23,104.39 163.92,103.7 173.99,103.7 174.67,103.02 177.98,103.02 178.36,102.64 181.75,102.64 184.2,100.19 184.2,97.57
PCIE_RX_DN_13_SSD: length 102.6
  TOP w0.076: U1.CP7 v1(181.48,83.02)
  TOP w0.109: CN10.5 110.17,73.22 v1(110.29,73.34)
  ART03 w0.075: 163.8,91.52 163.81,91.51 163.84,91.51 163.99,91.36 166.37,91.36 169,93.99 171.08,93.99 172.9,92.17 172.9,90.63 173.47,90.06 174.4,90.06 175.29,89.17 175.29,88.24 175.67,87.85 177.63,87.85 178.12,87.37 178.12,86.7 180.98,83.84 180.98,83.43 181.12,83.29 181.21,83.29 v1(181.48,83.02)
  ART03 w0.087: v1(110.29,73.34) 109.64,73.34 109.39,73.1 109.39,72.37 109.75,72.02 110.81,72.02 112.7,73.91 116.03,73.91 118.63,76.52 118.63,87.24 123.92,92.53 126.69,92.53 127.54,91.68 129.07,91.68 129.63,92.24 130.73,92.24 131.46,91.51 135.86,91.51 136.76,90.61 138.34,90.61 139.27,89.68 141.01,89.68 141.99,90.66 153.7,90.66 155.14,92.1 158.26,92.1 158.48,92.32 160.78,92.32 161.52,91.58 163.75,91.58 163.8,91.52
PCIE_RX_DN_14_SSD: length 118.7
  TOP w0.076: U1.CM7 v1(182.4,83.02)
  TOP w0.109: v1(104.62,76.9) 105,76.51 105.29,76.51 105.48,76.33 105.48,70.29 105.82,69.95 106.28,69.95 106.36,70.03 106.58,70.03 106.66,69.95 106.84,69.95 107.12,70.22 CN10.17
  ART03 w0.075: 176.75,97.57 176.75,97.55 176.76,97.54 176.76,97.33 179.62,94.48 179.62,86.05 181.85,83.81 181.85,83.5 182.04,83.32 182.3,83.32 182.4,83.22 v1(182.4,83.02)
  ART03 w0.087: 176.75,97.57 176.75,97.62 175.74,98.63 161.65,98.63 161.61,98.67 161.04,99.24 158.26,99.24 157.86,98.84 156.83,98.84 156.81,98.82 152.98,98.82 152.56,98.39 150.15,98.39 148.5,96.74 133.83,96.74 133.04,97.53 129.33,97.53 127.9,98.95 123.67,98.95 122.98,98.26 118.19,98.26 109.43,89.5 109.43,79.67 107.64,77.89 104.81,77.89 104.21,77.28 104.21,76.6 104.26,76.54 104.32,76.54 104.62,76.84 v1(104.62,76.9)
PCIE_RX_DN_15_SSD: length 126.8
  TOP w0.076: v1(183.31,83.02) 183.07,82.89 U1.CK7
  TOP w0.109: v1(102.87,76.61) 102.49,76.99 102.17,76.99 102.03,76.85 102.03,76.39 102.31,76.11 103.11,76.11 104.76,74.46 104.76,67.56 105.38,66.94 105.88,66.94 105.99,67.05 105.99,67.18 106.06,67.25 106.35,67.25 106.43,67.17 106.43,67.05 106.54,66.94 106.83,66.94 107.12,67.22 CN10.29
  ART03 w0.075: v1(183.31,83.02) 183.31,83.19 183.19,83.31 182.97,83.31 182.77,83.5 182.77,84.26 181.57,85.46 180.93,85.46 180.45,85.94 180.45,87.66 180.04,88.07 180.04,94.75 178,96.8 178,97.19 177.76,97.43 177.74,97.43 177.72,97.44
  ART03 w0.087: 177.72,97.44 176.05,99.11 161.98,99.11 161.16,99.94 157.8,99.94 157.4,99.54 152.63,99.54 152.15,99.06 149.84,99.06 148.26,97.47 140.2,97.47 139.97,97.7 133.8,97.7 133.31,98.19 129.59,98.19 128.16,99.62 125.65,99.62 125.28,99.99 118.93,99.99 108.62,89.69 108.62,80.85 106.36,78.59 104.56,78.59 103.54,77.57 103.54,76.98 103.33,76.76 103.03,76.76 v1(102.87,76.61)
PCIE_RX_DN_16_SSD: length 142.4
  TOP w0.076: U1.CJ6 v1(184.23,83.65)
  TOP w0.109: R337.1 114.15,67.28 115.43,68.56 115.43,75.99 114.59,76.84 106.38,76.84 v1(106.15,77.07)
  ART03 w0.075: v1(184.23,83.65) 183.99,83.4 183.95,83.4 183.87,83.48 183.87,84.85 182.64,86.08 181.24,86.08 180.94,86.38 180.94,88.01 180.51,88.45 180.51,97.15 180.12,97.54 180.12,97.56 180.11,97.57
  ART03 w0.087: v1(106.15,77.07) 106.36,76.86 107.04,76.86 107.42,76.48 107.42,76.03 106.99,75.6 103.88,75.6 103.56,75.92 102.58,75.92 102.21,76.3 102.21,77.82 103.9,79.51 105.95,79.51 107.71,81.27 107.71,89.98 118.61,100.87 128.11,100.87 129.95,99.03 133.71,99.03 134.21,98.54 146.29,98.54 146.65,98.9 148.47,98.9 149.49,99.92 151.77,99.92 152.51,100.66 161.39,100.66 161.39,100.64 162.25,99.78 176.48,99.78 176.85,99.41 178.27,99.41 180.11,97.57
PCIE_RX_DP<10>: length 156.6
  TOP w0.076: U1.CE7 v1(186.06,83.02)
  ART03 w0.075: v1(186.06,83.02) 186.26,83.22 186.48,83.22 186.65,83.39 186.65,83.93 187.02,84.3 187.02,84.91 186.51,85.41 186.51,86.8 185.59,87.72 185.59,92.99 185.72,93.12 185.72,97.55 185.73,97.56 185.73,97.57
  ART03 w0.087: v1(81.36,76.26) 81.5,76.4 81.5,76.73 81.77,77 85.1,77 87.29,74.8 91.4,74.8 103.04,86.43 103.04,89.95 117.55,104.46 123.75,104.46 124.45,105.17 128.25,105.17 131.2,102.21 139.94,102.21 140.7,102.98 140.7,103.85 142.04,105.19 149.81,105.19 150.16,105.54 163.9,105.54 164.29,105.15 165.91,105.15 166.08,104.98 174.34,104.98 175.1,104.22 182.33,104.22 185.73,100.82 185.73,97.57
  BOTTOM w0.109: C423.1 80.63,67.87 81.7,68.93 81.7,75.34 81.36,75.68 v1(81.36,76.26)
PCIE_RX_DP_5_GPU: length 147.4
  TOP w0.076: U1.DA7 v1(177.82,83.02)
  ART03 w0.075: 174.65,56.46 174.66,56.47 174.66,56.49 174.89,56.72 174.89,57.09 175.22,57.43 175.23,57.43 178.46,60.66 178.46,61.25 179.04,61.83 179.04,64.25 179.96,65.16 179.96,69.82 180.42,70.29 180.42,77.35 177.83,79.94 177.83,81.48 177.43,81.88 177.43,83.21 177.47,83.25 177.59,83.25 v1(177.82,83.02)
  ART03 w0.087: 174.65,56.46 166.94,48.75 164.94,48.75 162.31,46.12 162.31,43.09 158.29,39.07 156.38,39.07 v1(156.22,38.9)
  BOTTOM w0.109: v1(156.22,38.9) 156.43,39.11 157.22,39.11 157.9,38.44 177.54,38.44 179.71,40.61 183.63,40.61 183.63,40.61 185.2,40.61 187.01,42.42 208.28,42.42 210.09,40.61 214.81,40.61 216.39,42.18 225.65,42.18 226.04,42.57 226.04,50.5 228.82,53.29 230.52,53.29 230.81,53 CN14.42
PCIE_RX_DP_6_GPU: length 150.4
  TOP w0.076: v1(178.74,83.65) 178.65,83.39 178.53,83.34 178.3,83.42 U1.CY6
  ART03 w0.075: v1(178.74,83.65) 178.49,83.4 178.37,83.4 178.19,83.23 178.19,82.25 178.63,81.81 178.63,79.97 181.3,77.3 181.3,70.51 180.68,69.89 180.68,64.59 179.41,63.32 179.41,61.68 178.88,61.14 178.88,60.62 175.29,57.04 175.29,56.41 175.02,56.14 174.99,56.14 174.98,56.12
  ART03 w0.087: v1(156.36,37.61) 156.07,37.9 156.03,37.9 155.81,37.68 155.81,37.2 156.06,36.95 158.12,36.95 162.82,41.65 162.82,45.94 165.06,48.18 167.03,48.18 174.98,56.12
  BOTTOM w0.109: CN14.36 230.81,50.6 230.23,51.18 229.08,51.18 226.75,48.84 226.75,42.24 225.96,41.45 216.74,41.45 215.19,39.9 209.8,39.9 208.03,41.67 187.27,41.67 185.49,39.9 180,39.9 177.74,37.63 157.68,37.63 157.32,37.99 156.74,37.99 v1(156.36,37.61)
PCIE_RX_DP_7_GPU: length 112.6
  TOP w0.076: U1.CV6 v1(179.65,83.65)
  ART03 w0.075: 175.54,55.56 175.56,55.57 175.58,55.57 175.94,55.93 175.94,56.84 180.11,61 180.11,63.43 181.61,64.93 181.61,78.13 179.61,80.12 179.61,80.66 179.11,81.17 179.11,83.27 179.24,83.41 179.41,83.41 v1(179.65,83.65)
  ART03 w0.087: v1(165.13,46.71) 165.13,47.19 165.42,47.48 167.47,47.48 175.54,55.56
  BOTTOM w0.109: v1(165.13,46.71) 165.3,46.54 165.3,46.27 165.51,46.05 171.63,46.05 175.13,49.55 187.42,49.55 189.32,47.64 206.35,47.64 208.25,49.55 215.4,49.55 217.51,51.65 218.37,51.65 219.87,53.15 220.98,53.15 221.49,53.65 221.49,55.34 222.11,55.95 222.69,55.95 222.84,55.8 CN14.49
PCIE_RX_DP_8_GPU: length 117.7
  TOP w0.076: U1.CT7 v1(180.57,83.02)
  ART03 w0.075: v1(180.57,83.02) 180.33,83.26 180.22,83.26 180.17,83.21 180.17,82.54 180.25,82.46 180.32,82.46 180.4,82.38 180.4,82.23 180.33,82.16 180.25,82.16 180.17,82.09 180.17,80.58 183.03,77.72 183.03,70.34 182.69,69.99 182.69,64.58 182.84,64.44 182.84,62.63 176.91,56.7 176.91,55.4 176.33,54.82 176.33,54.8 176.32,54.78
  ART03 w0.087: 176.32,54.78 167.42,45.89 163.97,45.89 163.7,45.61 163.7,45.55 v1(164.09,45.16)
  BOTTOM w0.109: v1(164.09,45.16) 163.71,45.54 163.71,45.69 163.93,45.91 164.57,45.91 165.22,45.27 172.11,45.27 175.68,48.84 186.78,48.84 188.84,46.78 206.78,46.78 208.84,48.84 215.84,48.84 217.88,50.87 218.62,50.87 220.07,52.32 221.61,52.32 222.25,52.96 222.25,53.6 222.39,53.75 222.59,53.75 222.94,53.4 CN14.43
PCIE_RX_DP_9_WIFI: length 70.1
  TOP w0.076: U1.CG6 v1(185.14,83.65)
  TOP w0.109: CN22.41 141.39,98.61 141.6,98.4 141.71,98.4 141.79,98.48 141.79,101.39 142.75,102.35 142.75,103.41 142.69,103.47 142.55,103.47 v1(142.4,103.32)
  ART03 w0.075: v1(185.14,83.65) 185.14,83.53 185.34,83.34 185.46,83.34 185.54,83.42 185.54,84.04 185.47,84.11 185.31,84.11 185.25,84.17 185.25,84.34 185.32,84.41 185.47,84.41 185.54,84.49 185.54,84.64 185.47,84.71 185.26,84.71 185.19,84.79 185.19,84.94 185.26,85.01 185.47,85.01 185.54,85.09 185.54,85.41 185.07,85.89 185.07,86.92 184.71,87.29 184.71,89.41 184.03,90.09 184.03,97.54 184.02,97.55 184.02,97.57
  ART03 w0.087: v1(142.4,103.32) 142.82,103.74 143.15,103.74 143.2,103.79 150.36,103.79 150.78,104.2 163.15,104.2 163.84,103.51 173.92,103.51 174.59,102.84 177.9,102.84 178.28,102.46 181.68,102.46 184.02,100.12 184.02,97.57
PCIE_RX_DP_13_SSD: length 102.6
  TOP w0.076: U1.CP6 v1(181.48,83.65)
  TOP w0.109: CN10.7 108.71,72.72 108.99,73 109.15,73 109.3,72.85 109.3,72.79 109.38,72.72 109.6,72.72 109.71,72.82 109.71,72.86 109.85,73 110.03,73 v1(110.29,72.74)
  ART03 w0.075: v1(181.48,83.65) 181.27,83.44 181.19,83.44 181.13,83.5 181.13,83.9 178.27,86.77 178.27,87.43 177.7,88 175.74,88 175.44,88.3 175.44,89.23 174.47,90.21 173.53,90.21 173.05,90.69 173.05,92.23 171.14,94.14 168.94,94.14 166.31,91.51 164.05,91.51 163.94,91.62 163.94,91.64 163.93,91.65
  ART03 w0.087: 163.93,91.65 163.82,91.76 161.6,91.76 160.86,92.5 158.4,92.5 158.18,92.28 155.06,92.28 153.62,90.84 141.92,90.84 140.94,89.86 139.35,89.86 138.41,90.79 136.83,90.79 135.93,91.69 131.53,91.69 130.8,92.42 129.56,92.42 128.99,91.86 127.62,91.86 126.76,92.71 123.85,92.71 118.45,87.31 118.45,76.59 115.95,74.1 112.63,74.1 110.73,72.2 109.82,72.2 109.57,72.45 109.57,73.02 109.72,73.16 109.87,73.16 v1(110.29,72.74)
PCIE_RX_DP_14_SSD: length 118.7
  TOP w0.076: U1.CM6 v1(182.4,83.65)
  TOP w0.109: v1(104.62,76.3) 105.2,76.3 105.26,76.24 105.26,70.2 105.73,69.73 105.92,69.73 105.93,69.72 CN10.19
  ART03 w0.075: v1(182.4,83.65) 182.21,83.47 182.1,83.47 182,83.57 182,83.87 179.77,86.11 179.77,94.54 176.91,97.39 176.91,97.54 176.93,97.55 176.93,97.57
  ART03 w0.087: 176.93,97.57 176.93,97.7 175.82,98.81 175.76,98.81 175.74,98.79 161.75,98.79 161.14,99.4 158.2,99.4 157.79,99 152.9,99 152.48,98.58 150.07,98.58 148.42,96.93 133.9,96.93 133.11,97.71 129.4,97.71 127.98,99.13 123.59,99.13 122.9,98.44 118.11,98.44 109.25,89.58 109.25,79.75 107.57,78.07 104.73,78.07 104.02,77.36 104.02,76.52 104.19,76.36 104.55,76.36 v1(104.62,76.3)
PCIE_RX_DP_15_SSD: length 126.8
  TOP w0.076: v1(183.31,83.65) U1.CK6
  TOP w0.109: v1(102.87,77.21) 102.08,77.21 101.81,76.94 101.81,76.3 102.21,75.89 103.02,75.89 104.54,74.37 104.54,67.47 105.29,66.72 CN10.31
  ART03 w0.075: v1(183.31,83.65) 183.12,83.46 183.03,83.46 182.92,83.57 182.92,84.32 181.63,85.62 180.99,85.62 180.6,86 180.6,87.72 180.19,88.13 180.19,94.82 178.15,96.86 178.15,97.26 177.87,97.54 177.87,97.56 177.85,97.57
  ART03 w0.087: v1(102.87,77.21) 103.14,76.95 103.25,76.95 103.36,77.06 103.36,77.65 104.48,78.77 106.29,78.77 108.44,80.92 108.44,89.76 118.85,100.17 125.36,100.17 125.72,99.81 128.24,99.81 129.67,98.37 133.39,98.37 133.88,97.89 140.05,97.89 140.28,97.66 148.18,97.66 149.77,99.24 152.07,99.24 152.56,99.72 156.78,99.72 156.8,99.7 157.3,99.7 157.7,100.11 161.22,100.11 162.05,99.28 176.05,99.28 176.07,99.3 176.13,99.3 177.85,97.57
PCIE_RX_DP_16_SSD: length 142.3
  TOP w0.076: U1.CJ7 v1(184.23,83.01)
  TOP w0.109: R331.1 113.94,66.76 113.94,67.38 115.22,68.66 115.22,75.9 114.5,76.62 106.3,76.62 v1(106.15,76.47)
  ART03 w0.075: v1(184.23,83.01) 183.99,83.25 183.89,83.25 183.72,83.42 183.72,84.79 183.49,85.02 183.38,85.02 183.18,84.82 183.1,84.82 182.98,84.94 182.98,85.04 183.17,85.23 183.17,85.34 183.06,85.44 182.96,85.44 182.74,85.23 182.64,85.23 182.53,85.34 182.53,85.44 182.74,85.66 182.74,85.76 182.58,85.93 181.18,85.93 180.79,86.32 180.79,87.95 180.36,88.38 180.36,97.08 180.02,97.43 179.99,97.43 179.98,97.44
  ART03 w0.087: v1(106.15,76.47) 106.36,76.68 106.96,76.68 107.23,76.41 107.23,76.11 106.91,75.79 103.96,75.79 103.64,76.11 102.65,76.11 102.39,76.37 102.39,77.74 103.98,79.33 106.03,79.33 107.9,81.2 107.9,89.9 118.69,100.69 128.03,100.69 129.87,98.85 133.64,98.85 134.13,98.36 146.37,98.36 146.73,98.71 148.54,98.71 149.57,99.74 151.85,99.74 152.59,100.48 161.33,100.48 162.18,99.62 176.39,99.62 176.77,99.23 178.19,99.23 179.98,97.44
PCIE_TX_DN<10>: length 139.1
  TOP w0.075: C71.2 179.97,91.7 179.59,92.08 179.05,92.08 v1(179,92.13)
  ART03 w0.075: 176.24,97.57 176.26,97.56 176.26,97.54 176.58,97.21 176.58,96.92 178.48,95.02 178.48,91.97 178.59,91.87 178.74,91.87 v1(179,92.13)
  ART03 w0.087: v1(79.38,74.43) 79.14,74.19 79.14,73.78 79.56,73.36 84.41,73.36 85.46,72.32 90.24,72.32 90.65,71.91 94.02,71.91 94.36,72.26 104.45,72.26 105.36,73.17 107.7,73.17 108.3,73.77 108.3,76.97 109.97,78.65 109.97,89.37 118.4,97.79 123.18,97.79 123.83,98.44 127.73,98.44 129.13,97.04 132.82,97.04 133.62,96.24 151.12,96.24 153.22,98.35 161.45,98.35 162.07,97.72 165.38,97.72 165.79,97.32 165.82,97.32 166.08,97.05 166.72,97.05 166.97,97.3 166.99,97.3 167.36,97.68 167.41,97.72 170.18,97.72 170.71,98.25 175.56,98.25 176.24,97.57
  BOTTOM w0.109: U30.14 74.51,70.13 74.63,70.25 78.19,70.25 79.19,71.25 79.19,74.24 v1(79.38,74.43)
PCIE_TX_DN_5_GPU: length 2.6
  BOTTOM w0.109: CN14.39 222.81,51.8 222.43,51.42 221.82,51.42 C3.2
PCIE_TX_DN_6_GPU: length 2.6
  BOTTOM w0.109: CN14.33 222.61,49.4 222.32,49.11 221.71,49.11 C60.2
PCIE_TX_DN_7_GPU: length 2.6
  BOTTOM w0.109: C62.2 221.81,45.84 222.25,45.84 222.61,46.2 CN14.25
PCIE_TX_DN_8_GPU: length 2.7
  BOTTOM w0.109: C67.2 221.74,43.42 222.23,43.42 222.61,43.8 CN14.19
PCIE_TX_DN_9_WIFI: length 19.9
  TOP w0.109: CN22.37 139.9,99.61 139.75,99.77 138.54,99.77 137.87,99.1 137.87,95.84 136.55,94.51 136.55,91.23 136.88,90.91 136.88,87.85 135.67,86.64 132.93,86.64 C64.2
PCIE_TX_DN_13_SSD: length 3.6
  TOP w0.109: CN10.11 108.79,71.72 109.07,71.44 109.4,71.44 109.6,71.65 110.39,71.65 110.94,72.2 C73.2
PCIE_TX_DN_14_SSD: length 4
  TOP w0.109: CN10.23 108.6,68.72 108.82,68.51 109.4,68.51 110.08,69.18 110.52,69.18 110.61,69.27 110.61,69.57 110.79,69.75 C77.2
PCIE_TX_DN_15_SSD: length 4
  TOP w0.109: C79.2 110.78,67.06 110.46,67.06 108.98,65.58 108.78,65.58 108.64,65.72 CN10.35
PCIE_TX_DN_16_SSD: length 6.1
  TOP w0.076: U1.CW5 178.83,84.52 178.87,85.04 178.87,85.05 178.94,85.21 178.99,85.33 178.99,85.64 178.96,85.7 178.95,85.86 179,86.05 179,86.38 178.81,86.58 178.81,88.62 178.16,89.28 178.16,89.44 C277.2
PCIE_TX_DP<10>: length 139.3
  TOP w0.075: v1(179,91.53) 179.4,91.93 179.52,91.93 179.82,91.63 179.82,91.25 C72.2
  ART03 w0.075: v1(179,91.53) 178.81,91.72 178.52,91.72 178.33,91.91 178.33,94.96 176.43,96.86 176.43,97.15 176.15,97.43 176.13,97.43 176.11,97.44
  ART03 w0.087: v1(78.78,74.43) 78.96,74.25 78.96,73.7 79.49,73.18 84.34,73.18 85.38,72.14 90.17,72.14 90.58,71.73 94.09,71.73 94.44,72.07 104.52,72.07 105.43,72.98 107.78,72.98 108.48,73.69 108.48,76.89 110.16,78.57 110.16,89.29 118.47,97.61 123.25,97.61 123.9,98.26 127.65,98.26 129.06,96.85 132.75,96.85 133.54,96.06 151.19,96.06 153.3,98.16 161.4,98.16 162,97.56 165.32,97.56 166.01,96.87 166.79,96.87 167.48,97.56 170.24,97.56 170.77,98.09 175.47,98.09 176.11,97.44
  BOTTOM w0.109: v1(78.78,74.43) 78.97,74.24 78.97,71.34 78.1,70.47 77.59,70.47 77.36,70.7 77.01,70.7 76.78,70.47 74.56,70.47 74.49,70.53 U30.13
PCIE_TX_DP_5_GPU: length 2.5
  BOTTOM w0.109: CN14.37 222.76,51 222.56,51.2 221.71,51.2 C12.2
PCIE_TX_DP_6_GPU: length 2.6
  BOTTOM w0.109: CN14.31 222.61,48.6 222.32,48.89 221.67,48.89 C61.2
PCIE_TX_DP_7_GPU: length 2.5
  BOTTOM w0.109: C66.2 221.63,45.62 222.39,45.62 222.61,45.4 CN14.23
PCIE_TX_DP_8_GPU: length 2.5
  BOTTOM w0.109: C133.2 221.59,43.2 222.41,43.2 222.61,43 CN14.17
PCIE_TX_DP_9_WIFI: length 19.9
  TOP w0.109: C65.2 132.93,86.85 135.58,86.85 136.66,87.94 136.66,90.81 136.33,91.14 136.33,94.6 137.66,95.93 137.66,99.19 138.45,99.98 139.76,99.98 139.89,100.11 CN22.35
PCIE_TX_DP_13_SSD: length 3.3
  TOP w0.109: C74.2 109.69,71.43 109.49,71.22 CN10.13
PCIE_TX_DP_14_SSD: length 3.5
  TOP w0.109: CN10.25 108.6,68.22 108.67,68.29 109.49,68.29 110.17,68.96 C78.2
PCIE_TX_DP_15_SSD: length 4
  TOP w0.109: C81.2 110.81,66.84 110.55,66.84 109.07,65.36 108.76,65.36 108.62,65.22 CN10.37
PCIE_TX_DP_16_SSD: length 6.1
  TOP w0.076: C278.2 177.84,89.49 177.84,89.27 177.77,89.21 177.77,89.1 177.88,88.99 177.99,88.99 178.05,89.06 178.16,89.06 178.27,88.95 178.27,88.84 178.2,88.78 178.2,88.67 178.31,88.56 178.42,88.56 178.49,88.63 178.59,88.63 178.66,88.56 178.66,86.48 178.83,86.31 178.83,86.08 178.77,85.89 178.78,85.65 178.81,85.59 178.81,85.37 178.75,85.21 178.71,85.12 U1.CW3
PD#: length 12.7
  TOP w0.102: U25.47 32.39,77.05 33.32,76.12 33.32,74.89 34.08,74.13 34.08,66.29 33.73,65.94 U23.4
PECIRQT#: length 3.3
  BOTTOM w0.102: R1400.2 57.9,66.34 57.55,66.34 57.23,66.66 57.23,67.08 57.05,67.26 56.73,67.26 56.33,67.65 U9.118
PEDET: length 5.2
  TOP w0.102: R273.1 111.79,58.66 Q40.1 111.32,57.41 R338.1 110.48,57.22 R535.1 CN10.69
PEX_RST: length 9.4
  TOP w0.102: R518.1 231.82,44.12 231.57,44.38 v1(230.53,44.38) 230.89,44.73 U33.4 230.89,46.18 231.19,46.48 232.67,46.48 232.86,46.66 232.86,48.27 R515.2
  BOTTOM w0.102: CN14.22 230.83,45 230.53,44.7 v1(230.53,44.38)
PHASE1: length 96.2
  TOP w0.305: v1(192.86,102.3) 193.24,102.68 LPM1.1
  ART06 w0.203: v1(192.86,102.3) 193.11,102.05 194,102.05 194.14,102.19 194.14,102.81 192.24,104.71 189.02,104.71 188.02,105.71 188.02,108.18 189.68,109.83 219.11,109.83 220.98,111.7 222.35,111.7 222.89,111.16 222.92,111.1 222.92,109.76 v1(222.89,109.74)
  ART06 w0.508: v2(194.1,106.07) 194.87,106.07 200.39,100.55 209,100.55 209.58,101.13 217.97,101.13 221.52,104.69 225.38,104.69 226.1,103.96 228.83,103.96 v2(228.9,104.04)
  BOTTOM w0.203: 228.84,104.1 228.46,104.1 228.18,103.82 227.94,103.82 227.5,103.39 U3.34
  BOTTOM w0.305: PR25.2 223.38,108.93 223.06,109.25 223.06,109.58 v1(222.89,109.74)
  BOTTOM w0.508: PC11.1 228.97,104.1 v2(228.9,104.04) 228.84,104.1
PHASE2: length 109.4
  TOP w0.305: v1(185.66,102.49) 185.59,102.41 184.39,102.41 184.04,102.76 LPM2.1
  ART06 w0.203: v1(185.66,102.49) 186.02,102.13 186.58,102.13 186.86,102.41 186.86,108.83 188.92,110.89 216.87,110.89 218.07,112.09 218.07,112.8 v1(217.99,112.87)
  ART06 w0.508: v2(228.12,101.12) 228.11,101.12 227.71,100.73 227.71,100.14 226.22,98.64 222.86,98.64 222.3,98.08 218.61,98.08 217.53,97 192.06,97 189.5,99.55 184.29,99.55 183.3,100.54 v2(183.3,110.54)
  BOTTOM w0.203: U3.38 227.02,101.79
  BOTTOM w0.305: PR49.2 217.56,110.84 217.56,111.03 218.04,111.51 218.04,112.83 v1(217.99,112.87) ; 227.93,101.18 227.32,101.79 227.02,101.79
  BOTTOM w0.508: PC10.1 229.64,100.37 228.89,101.12 v2(228.12,101.12) 228.06,101.18 227.93,101.18
PHASE3: length 32.3
  TOP w0.203: v1(223.04,112.19) 221.32,112.19 219.69,110.57 219.69,102.89 217.83,101.02 213.1,101.02 212.96,101.16 LPM3.1
  TOP w0.508: 211.62,110.3 211.62,112.43 PR67.1 ; 209.99,105.06 209.99,105.14 210.37,105.51 ; 209.99,105.06 210.77,105.06 ; 209.99,105.06 210.32,104.74 ; 209.99,105.06 PR73.2 207.59,105.06 v1(207.3,104.77)
  BOTTOM w0.305: v1(207.3,104.77) 206.97,104.77 206.94,104.75 PU3.2 ; PR79.2 223.28,111.95 v1(223.04,112.19)
  BOTTOM w0.508: v2(211.67,106) 211.67,104.09 211.21,103.63 PC12.2
PLT_RST_BUF#: length 429.6
  TOP w0.102: v1(155.38,45.58) 149.89,45.58 147.72,47.75 147.72,49.19 145.34,51.57 145.34,53.77 144.57,54.54 144.57,58.48 145.12,59.03 147.46,59.03 v1(147.67,58.82) 147.82,58.97 147.82,61 148.38,61.55 148.87,61.55 U5.4 ; v1(231.1,58) 231.4,57.7 U32.2 ; v1(93.68,69.28) 95.04,67.93 U40.1 95.69,63.28 R525.1
  TOP w0.114: R514.1 231.7,52.31 231.4,52.6 U32.2
  ART03 w0.102: v1(83.2,69.88) 83.38,69.69 86.29,69.69 v1(87.27,68.72) 87.27,68.62 87.62,68.27 92.67,68.27 v1(93.68,69.28) 94.34,69.94 95.28,69.94 96.23,70.88 107.3,70.88 107.5,71.08 111.12,71.08 113.02,72.98 117.16,72.98 117.72,73.54 118.31,73.54 120.44,75.67 120.44,77.85 120.07,78.22 120.07,86.7 122.68,89.32 123.43,89.32 125.31,91.19 125.65,91.19 126.43,91.97 v1(126.43,92.14)
  ART06 w0.102: v1(126.43,92.14) 126.71,91.86 129.64,91.86 138.42,83.08 138.42,68.95 143.53,63.84 145.34,63.84 147.09,62.1 147.09,60.69 148.04,59.73 148.04,59.19 v1(147.67,58.82) ; v1(83.2,69.88) 82.43,70.64 77.49,70.64 76.77,71.37 70.93,71.37 67.22,67.66 61.92,67.66 61.22,68.36 61.22,73.56 59.3,75.48 58.59,75.48 57.94,76.14 53.14,76.14 51.85,74.86 51.25,74.86 50.52,74.13 48.38,74.13 47.92,74.59 46.14,74.59 45.34,75.38 45.34,77.72 45.5,77.89 45.5,79.06 45.88,79.44 46.63,79.44 47.33,80.15 v1(47.33,80.45) ; v1(231.1,58) 231.15,58 231.12,57.97 231.12,43.76 230.28,42.92 230.28,38.96 228.5,37.18 228.5,33.92 229.71,32.71 229.71,32.14 230.13,31.72 230.13,28.42 229.18,27.47 229.18,18.26 228.36,17.44 228.36,14.48 226.48,12.6 157.92,12.6 155.59,14.93 155.59,17.19 156.71,18.32 156.71,25.43 155.89,26.25 155.89,29.01 157.05,30.16 157.05,35.11 157.51,35.57 157.51,42.54 155.38,44.67 v1(155.38,45.58)
  BOTTOM w0.102: R358.2 77.57,64.65 79.41,64.65 79.64,64.42 U18.1 81.26,63.77 ; v1(87.27,68.72) 87.27,62.21 79.14,54.09 75.38,54.09 74.14,52.84 67.24,52.84 66.16,51.76 66.16,27.78 U57.1 65.6,27.71 R1397.2 66.04,27.06 U57.2 ; v1(126.43,92.14) 126.53,92.24 U10.1 ; R168.1 v1(47.33,80.45)
  BOTTOM w0.109: v1(83.2,69.88) 83.27,69.81 83.27,68.83 83.47,68.63 83.47,65.99 81.26,63.77
  BOTTOM w0.305: R244.1 127.23,93.76 U10.1
PLTRST_PEG_SLOTS_N: length 4
  TOP w0.102: U33.1 232.19,48.55 R515.1 232.19,49.34 DR1.2 232.18,50.68 R513.1
PM_BATLOW#: length 162.9
  TOP w0.075: 169.17,58.67 169.72,58.11 170.43,58.11 170.98,58.67 ; R69.2 165.15,58.41 164.14,58.41 163.87,58.14 162.94,58.14 162.71,58.37 161.97,58.37
  TOP w0.076: 170.98,58.67 173.76,61.45 173.76,62.04 173.65,62.15 173.65,62.41 173.75,62.67 173.75,62.85 U1.DH48 ; 169.17,58.67 165.82,58.67 R69.2
  TOP w0.102: v1(162.14,54.56) 161.96,55.01 161.96,55.42 160.95,56.43 160.95,57.77 161.56,58.37 161.97,58.37
  ART06 w0.102: v1(50.27,73.67) 50.5,73.67 51.42,74.59 52.15,74.59 52.79,75.23 59.1,75.23 60.96,73.37 60.96,68.19 62.25,66.9 69.4,66.9 70.41,67.91 75.3,67.91 79.24,63.97 84.94,63.97 86.86,65.89 99.58,65.89 100.21,66.52 105.8,66.52 106.56,65.76 108.32,65.76 108.61,65.48 114.83,65.48 115.12,65.77 117.64,65.77 118.74,64.67 127.66,64.67 128.67,63.66 133.79,63.66 136.55,60.91 138.05,60.91 140.33,58.63 142.04,58.63 142.71,57.96 142.71,57.24 146.56,53.39 152.08,53.39 152.39,53.7 156.29,53.7 156.65,53.34 161.2,53.34 162.14,54.29 v1(162.14,54.56)
  BOTTOM w0.102: U9.21 46.16,64.81 49.97,68.62 49.97,72.39 50.27,72.69 v1(50.27,73.67)
PM_CPUPWRGD: length 0.9
  TOP w0.102: U1.CF1 184.85,86.52 v1(184.51,86.86)
PM_EC_PWRBTN#: length 171.3
  TOP w0.076: U1.CY42 178.33,65.91 178.43,65.86 v1(178.49,65.83)
  ART06 w0.102: v1(51.23,72.56) 51.71,73.04 54.29,73.04 55.55,71.77 55.55,66.88 56.64,65.8 57.28,65.8 59.53,63.55 60.87,63.55 61.61,62.81 61.61,62.52 61.81,62.31 64.02,62.31 65.08,63.36 73.39,63.36 73.85,62.9 76.14,62.9 76.73,62.3 80.31,62.3 82.36,60.26 90.35,60.26 93.21,63.12 105.43,63.12 106.03,62.51 109.61,62.51 111.54,60.58 112.11,60.58 113.03,61.5 114.56,61.5 115.09,60.97 115.86,60.97 118.37,63.48 123.52,63.48 125.02,61.98 133.83,61.98 138.78,57.03 138.78,56.05 139.56,55.28 143.1,55.28 146.84,51.53 151.75,51.53 152.6,50.68 154.98,50.68 155.24,50.42 164.5,50.42 170.95,56.87 170.95,57.27 173.14,59.46 174.93,59.46 176.02,60.54 176.02,61.59 178.49,64.07 v1(178.49,65.83)
  BOTTOM w0.075: R28.2 176.56,64.74 177.67,64.74 178.27,65.33 178.27,65.61 v1(178.49,65.83)
  BOTTOM w0.102: v1(51.23,72.56) 50.94,72.27 50.94,69.03 46.96,65.05 U9.19
PM_LANPHY_ENABLE: length 9.3
  TOP w0.075: TP10.1 169.79,57.13 169.99,57.33 170.44,57.33
  TOP w0.076: 170.44,57.33 174.2,61.08 174.54,61.08 174.9,61.45 174.9,62.52 U1.DF48
PM_RSMRST#: length 150.1
  TOP w0.075: 170.49,57.61 167.95,57.61 167.31,58.26 164.26,58.26 163.9,57.9 163.47,57.47 R108.1 163.14,57.47 162.58,58.03 161.97,58.03
  TOP w0.076: U1.DG49 174.51,62.45 174.66,62.3 174.66,61.47 174.48,61.29 174.16,61.29 170.49,57.61
  TOP w0.102: v1(162.6,54.92) 162.6,54.94 162.39,55.16 162.39,55.47 161.33,56.52 161.33,57.73 161.62,58.03 161.97,58.03
  ART06 w0.102: v1(53.38,74.72) 53.47,74.72 53.73,74.98 57.72,74.98 58.11,74.59 58.11,74.22 58.57,73.76 58.57,70.16 62.32,66.41 69.42,66.41 70.59,67.59 75.21,67.59 79.09,63.71 87.53,63.71 89.51,65.69 99.67,65.69 100.29,66.32 105.72,66.32 106.48,65.56 108.24,65.56 108.57,65.24 114.88,65.24 115.21,65.56 117.38,65.56 118.54,64.4 127.59,64.4 128.55,63.44 133.73,63.44 139.86,57.3 139.86,56.53 140.09,56.3 143.27,56.3 147.09,52.48 152.13,52.48 153.13,53.48 155.84,53.48 156.37,52.94 161.15,52.94 162.62,54.42 162.62,54.77 162.6,54.8 v1(162.6,54.92)
  BOTTOM w0.114: U9.93 52.96,75.13 v1(53.38,74.72)
PM_SLP_S0#: length 163.3
  TOP w0.102: R412.2 153.66,46.1 154.57,46.1 155.18,46.71 159.05,46.71 159.76,47.42 v1(159.8,47.42) 160.2,47.42 161.36,46.26 176.19,46.26 178.91,48.98 178.91,52.13 178.76,52.28 178.76,54.53 178.02,55.27 178.02,56.08 R68.2
  ART06 w0.102: v1(159.8,47.42) 159.82,47.44 159.26,48 154.03,48 153.81,47.78 149.55,47.78 148.85,48.48 147.65,48.48 142.6,53.52 138.95,53.52 133.21,59.25 124.85,59.25 123.3,60.8 119.19,60.8 117.75,59.36 113.29,59.36 112.71,58.77 104.27,58.77 101.91,61.14 93.63,61.14 91.44,58.95 79.81,58.95 78.52,60.23 72.11,60.23 71.58,60.76 60.7,60.76 v1(59.43,62.03)
  BOTTOM w0.102: U9.128 55.61,63.2 57.23,61.58 58.99,61.58 v1(59.43,62.03) ; R353.1 157.66,55.24 157.15,55.75 156.72,55.75 156.55,55.58 156.55,54.25 157.4,53.4 157.4,49.7 159.67,47.42 v1(159.8,47.42)
PM_SLP_S3#: length 208.7
  TOP w0.203: v1(155,67.03) 155.07,66.96 R381.1 156.72,66.94 R83.2 ; U55.3 v1(147.07,73.99) ; Q79.1 79.14,68.02 79,67.89 v1(79,66.63)
  ART03 w0.203: v1(128.22,76.71) 128.22,76.96 135.64,84.37 146.35,84.37 148.07,82.66 148.07,81.8 148.35,81.52 150.43,81.52 v1(150.61,81.7) ; v1(49.22,69.27) 49.42,69.07 53.52,69.07 54.03,68.56 54.78,68.56 55.26,69.04 61.37,69.04 61.75,68.66 62.91,68.66 63.99,67.57 78.06,67.57 v1(79,66.63)
  ART06 w0.203: v1(155,67.03) 154.77,67.26 154.23,67.26 151.11,70.39 149.96,70.39 148.71,71.65 148.71,72.19 147.07,73.83 v1(147.07,73.99) ; v1(79,66.63) 80.11,67.74 v1(105.98,67.74) 106.46,67.26 117.54,67.26 v1(117.86,66.94) 119.31,65.5 125.59,65.5 126.3,66.21 126.3,69.89 127.26,70.85 129.36,70.85 129.79,71.29 129.79,75.23 128.31,76.71 v1(128.22,76.71)
  BOTTOM w0.203: v1(49.22,69.27) 49.28,69.33 49.28,73.53 48.34,74.48 48.34,75.35 47.76,75.92 U9.80 ; R790.1 117.86,67.51 v1(117.86,66.94) ; v1(147.07,73.99) 147.92,73.99 148.19,74.27 148.19,74.98 147.16,76.01 147.16,77.4 D71.P 148.56,78.79 148.56,80.71 149.24,81.39 150.3,81.39 v1(150.61,81.7) ; U2.7 112.26,53.8 112.06,53.59 112.06,53.14 111.65,52.73 R118.1 R117.1 111.4,51.58 111.26,51.45 108.59,51.45 108.21,51.07 108.21,50.52 107.23,49.54 102.71,49.54 100.87,51.38 100.87,55.69 104.19,59.01 104.19,65.95 v1(105.98,67.74) ; v1(155,67.03) 154.89,66.92 154.89,62.05 154.9,62.05 157.79,59.17 157.79,58.68 158.51,57.96 159.68,57.96 160.41,57.22 160.41,55.11 U54.2
PM_SLP_S4#: length 331.4
  TOP w0.075: R103.2 175.28,59.89 R382.1 174.5,59.23 173.94,59.23 173.22,58.51 173.22,56.36 172.96,56.1
  TOP w0.102: v1(152.75,59.42) 153.35,58.82 153.35,57.3 156.7,53.95 162.62,53.95 163.25,54.58 163.89,54.58 165.72,56.41 168.23,56.41 170.4,54.25 170.85,54.25 171.5,54.9 171.75,54.9 172.96,56.1
  TOP w0.203: v1(78.76,75.82) 78.74,75.85 78.72,75.85 78.26,75.39 78.26,73.96 79.14,73.09 Q77.1 79.14,70.42 79.94,69.61 79.94,68.59 80.81,67.73 82.57,67.73 83.12,67.17 83.12,58.75 80.93,56.56 80.93,54.23 v1(80.57,53.87)
  ART03 w0.203: v1(109.22,55.59) 109.22,55.36 109.51,55.07 110.71,55.07 111.28,55.63 123.19,55.63 124.22,56.67 125.56,56.67 127.61,58.72 129.21,58.72 130.34,59.85 136.24,59.85 137.25,60.86 145.89,60.86 146.06,61.03 147.57,61.03 148.21,60.39 151.78,60.39 v1(152.75,59.42)
  ART06 w0.203: v1(78.76,75.82) 78.76,75.9 78.63,75.9 78.08,75.36 68.77,75.36 67.91,76.22 66.67,76.22 64.03,78.86 62.68,78.86 61.56,77.74 54.75,77.74 54.52,77.97 48.31,77.97 v1(47.54,78.74) ; v1(154.18,18.49) 154.18,29.68 153.48,30.38 153.48,34 153.96,34.48 153.96,43.13 151.81,45.28 144.92,45.28 139.92,50.28 139.92,50.77 135.56,55.12 127.68,55.12 125.47,57.34 116.59,57.34 115.01,55.75 111.28,55.75 110.56,55.03 109.49,55.03 109.22,55.3 v1(109.22,55.59) 108.67,55.05 105.78,55.05 104.27,56.56 100.77,56.56 100.18,57.15 96.6,57.15 94.71,55.26 81.96,55.26 v1(80.57,53.87)
  BOTTOM w0.102: R185.2 208.18,12.79 207.53,12.13 193.57,12.13 193.04,11.6 159.36,11.6 154.18,16.78 v1(154.18,18.49)
  BOTTOM w0.203: v1(152.75,59.42) 152.47,59.42 151.02,60.88 151.02,69.31 148.69,71.63 148.69,75.67 D70.P ; R112.1 109.84,54.29 109.22,54.9 v1(109.22,55.59) ; U9.79 47.36,78.56 v1(47.54,78.74)
PM_SLP_SUS#: length 242.8
  TOP w0.305: v1(146.33,81.74) 146.28,81.68 R896.1 ; v1(96.56,89.07) 96.56,89.38 95.83,90.11 R897.1
  ART03 w0.203: v1(167.38,61.3) 166.08,61.3 164.85,60.07 155.32,60.07 153.44,61.96 149.56,61.96 148.85,62.68 137.44,62.68 136.91,62.15 135.73,62.15 135.3,61.73 130.5,61.73 128.66,59.88 126.82,59.88 124.77,57.83 123.09,57.83 122.37,57.11 115.44,57.11 v1(115.39,57.16)
  ART03 w0.305: v1(146.33,81.74) 146.13,81.94 140.98,81.94 140.09,81.06 135.17,81.06 133.5,79.39 133.5,74.48 132.88,73.86 132.16,73.86 130.57,75.46 126.97,75.46 119.33,67.81 114.46,67.81 v1(112.64,66)
  ART06 w0.203: v1(49.22,66.22) 50.98,64.46 50.98,59.3 54.28,56 75.02,56 75.36,55.66 94.65,55.66 96.59,57.6 100.28,57.6 101.01,56.87 104.94,56.87 105.78,56.03 107.1,56.03 107.24,56.17 114.39,56.17 v1(115.39,57.16)
  ART06 w0.305: v1(117.01,85.92) 113.88,89.05 96.58,89.05 v1(96.56,89.07)
  BOTTOM w0.203: v1(167.38,61.3) R377.1 167.93,61.97 168.38,62.42 R101.1 ; U9.17 47.76,64.76 v1(49.22,66.22)
  BOTTOM w0.305: R792.2 115.85,79.81 114.64,78.6 114.64,67.99 v1(112.64,66) 112.64,63.57 114.12,62.09 116.01,62.09 116.74,61.36 116.74,59.25 115.39,57.89 v1(115.39,57.16) ; R792.2 117.01,78.5 Q76.1 ; R792.2 v1(117.01,85.92)
POWSW#: length 37.2
  TOP w0.305: v1(90.99,113.96) 88.54,113.96 88.05,113.48 88.05,111.87 87.27,111.09 D19.N D20.N 89.84,110.35 90.47,109.72 R174.1 ; v1(109.55,114.42) 109.25,114.11 SW1.1
  ART06 w0.305: v1(98.01,114.63) 97.52,114.15 91.17,114.15 v1(90.99,113.96)
  BOTTOM w0.305: v1(98.01,114.63) 98.01,110.45 D58.1 99.36,110.33 C3218.2 100.83,110 C6064.1 104.34,113.5 108.64,113.5 v1(109.55,114.42)
PROCHOT#_EC: length 8.9
  TOP w0.102: U34.2 43.17,61.54 43.45,61.82 45.85,61.82 v1(46.56,61.11)
  BOTTOM w0.102: R325.2 45.24,59.42 R548.2 45.24,59.8 v1(46.56,61.11) 46.56,61.11 U9.20
PRSNT_R#: length 12.5
  BOTTOM w0.075: 221.25,58.72 220.88,58.72 R511.1
  BOTTOM w0.102: CN14.48 228.19,55.4 225.25,58.33 222.84,58.33 222.46,58.72 221.25,58.72
PS_LATCH#: length 21.3
  TOP w0.203: D19.P 87.27,113.47 88.29,114.49 91.82,114.49 v1(91.99,114.65)
  TOP w0.305: 91.54,114.49 91.63,114.4 91.63,113.62 91.14,113.13 91.14,112.63 D72.P ; D19.P 87.02,112.91 86.29,112.91 85.72,112.34 R172.2 84.89,108.56 Q31.3
  BOTTOM w0.203: v1(91.99,114.65) 94.57,112.07 Q30.1
PS_S3CNTRL: length 37.3
  ART06 w0.203: v1(105.34,65.23) 105.34,65.16 106.38,64.12 116.46,64.12 v1(116.67,64.33)
  BOTTOM w0.203: v1(105.34,65.23) 105.33,65.23 104.74,64.64 104.74,58.9 101.33,55.49 101.33,51.74 102.82,50.24 Q4.1
  BOTTOM w0.305: Q71.3 Q69.1 117.72,64.08 118.1,63.7 R788.2 R203.2 116.67,63.79 v1(116.67,64.33)
PWM: length 4.4
  BOTTOM w0.305: R522.2 30.05,41.01 R529.2 30.05,42.64 R527.1 30.05,42.66 R530.2 R532.2 30.56,44.77 U37.16
PWR_LED_BLUE: length 107.2
  TOP w0.305: v1(120.56,111.21) 120.81,111.46 Q36.1
  ART03 w0.102: v1(49.64,87.53) 49.32,87.85 49.32,89.48 51.9,92.06 51.9,100.27 55.19,103.56 55.19,106.07 56.96,107.84 61.88,107.84 64.95,110.91 74.69,110.91 75.98,109.62 83.23,109.62 83.69,110.08 102.92,110.08 103.68,110.83 111.07,110.83 111.67,111.44 120.14,111.44
  ART03 w0.305: 120.14,111.44 120.33,111.44 v1(120.56,111.21)
  BOTTOM w0.102: U9.95 53.76,78.52 54.15,78.91 54.15,79.64 53.18,80.61 53.18,84.67 54.63,86.12 54.63,87.49 54.44,87.68 49.8,87.68 v1(49.64,87.53)
PWRONLATCHG: length 17.9
  TOP w0.203: v1(85.75,107.25) 85.72,107.28 R172.1
  TOP w0.305: v1(99.08,107.46) 98.95,107.33 Q17.4 ; R170.1 C228.2 C229.1 R172.1
  ART06 w0.305: v1(85.75,107.25) 85.85,107.15 98.77,107.15 v1(99.08,107.46)
R_OUT+: length 4.3
  TOP w0.508: CN8.2 228.29,112.32 D62.N 227.31,112.22 C6123.1 226.33,112.47 R268.2
R_OUT-: length 6
  TOP w0.508: CN8.1 228.44,111.07 D61.N 227.14,111.31 C6124.1 226.52,111.24 226.46,111.18 226.27,111.1 224.79,111.1 224.6,111.3 R267.2
REXT: length 2.7
  BOTTOM w0.102: U42.26 50.53,21.73 49.02,20.21 R608.2
RLV_AMP: length 3.1
  BOTTOM w0.102: R607.2 48.24,20.25 49.34,21.34 49.79,21.34 50.13,21.68 U42.27
RLV_CFG: length 6.2
  BOTTOM w0.102: R603.1 49.47,18.16 49.47,19.5 R604.2 50.4,20.43 50.92,20.43 51.17,20.68 51.68,20.68 52.13,21.14 U42.22
RLV_LNK: length 11.3
  BOTTOM w0.102: U42.21 52.53,21.19 51.82,20.48 51.32,20.48 50.78,19.94 R598.2 51.15,19.49 51.15,18.18 R597.1 51.15,17.26 51.15,15.7 49.61,14.15 U44.7
ROP_VCCST_PWRGD: length 10.1
  TOP w0.102: R116.2 R119.1 47.86,70.77 Q13.1 47.86,74.26 48.62,75.03 v1(49.75,75.03)
  BOTTOM w0.102: v1(49.75,75.03) 49.75,77.49 U9.85
RSET: length 3.7
  BOTTOM w0.127: R493.2 68.59,74.37 68.59,72.62 69.47,71.73 U30.31
RT3614_DRVEN: length 43.7
  ART06 w0.508: v2(209.06,106.09) 211.59,108.62 219.75,108.62 219.99,108.86 223.88,108.86 224.4,109.38 230.26,109.38 233.13,106.51 233.13,100.56 230.5,97.94 228.27,97.94 v2(228.21,98)
  BOTTOM w0.203: 225.74,99.61 225.44,99.61 225.3,99.75 U3.2
  BOTTOM w0.305: PR11.1 209.05,106.08 v2(209.06,106.09) ; 225.74,99.61 226.29,99.61
  BOTTOM w0.508: v2(228.21,98) 227.47,98.74 PR93.2 226.8,99.61 226.29,99.61
RT3614_ISEN1N: length 3.9
  BOTTOM w0.203: U3.23 222.9,105.68 222.32,106.26 221.68,106.26 221.63,106.31
  BOTTOM w0.305: R781.1 220.5,107.45 221.63,106.31
RT3614_ISEN1P: length 3.8
  BOTTOM w0.203: U3.24 223.3,105.76 PR28.2
  BOTTOM w0.305: PR28.2 222.07,106.98 PR31.2 222.07,107.77 PC8.2
RT3614_ISEN2N: length 8.6
  BOTTOM w0.203: U3.22 222.5,105.65 222.23,105.92 221.21,105.92 219.99,107.14 218.88,107.14 218.3,107.72 218.3,108.17 219.37,109.24 219.79,109.24 R784.1
RT3614_ISEN2P: length 10.8
  BOTTOM w0.203: U3.21 221.29,105.26 220.99,105.56 220.99,105.69 219.86,106.83 218.75,106.83 217.99,107.59 217.99,108.42 218.55,108.98 218.55,109.42 218.21,109.76 ; PR45.2 217.47,108.79 218.21,109.53 PR54.2 218.21,109.76 ; 218.21,109.76 PC21.2
RT3614_ISEN3N: length 9.1
  BOTTOM w0.203: 224.54,109.83 224.23,109.51 224.23,106.06 224.1,105.93 U3.26
  BOTTOM w0.305: 224.54,109.83 224.54,111.16 224.91,111.53 226.67,111.53 227.11,111.97 R785.1
RT3614_ISEN3P: length 8.9
  BOTTOM w0.203: 223.99,110.02 223.89,109.92 223.89,106.16 223.7,105.97 U3.25
  BOTTOM w0.305: 223.99,110.02 223.99,111.26 224.44,111.71 PR46.2 224.57,112.08 PR2.1 225.47,112.08 PC39.2
RT3614_PWM3: length 27.3
  ART06 w0.508: v2(226.69,105.58) 226.69,105.85 225.37,107.17 220.96,107.17 218.46,104.66 217.1,104.66 216.2,105.56 214,105.56 213.06,104.62 209.25,104.62 v2(206.91,102.27)
  BOTTOM w0.203: 226.45,104.99 226.37,104.92 U3.31
  BOTTOM w0.305: 205.09,103.4 PU3.5
  BOTTOM w0.508: v2(206.91,102.27) 206.22,102.27 205.09,103.4 ; 226.45,104.99 226.45,105.37 226.66,105.58 v2(226.69,105.58)
RT6543_ISEN1N: length 3.5
  BOTTOM w0.203: PR117.1 161.04,97.89 161.04,96.95 161.19,96.81 162.54,96.81 162.74,96.61 U6.3
RT6543_ISEN1P: length 3.4
  BOTTOM w0.203: PR116.1 160.49,96.82 160.91,96.4 162.51,96.4 162.7,96.21 U6.2
RT6543A_LG: length 21.6
  TOP w0.508: v2(160.84,109.89) 160.64,110.09 PR40.1
  ART06 w0.508: v2(160.84,109.89) 160.84,106.37 164.16,103.05 168.08,103.05 169.09,102.05 v2(169.09,101.48)
  BOTTOM w0.203: 167.42,96.61 U6.13
  BOTTOM w0.508: 167.42,96.61 169.02,98.21 169.02,101.41 v2(169.09,101.48)
RT6543A_PHASE: length 22.4
  TOP w0.203: 158.21,99.46 159.99,99.46 160.3,99.16 160.3,98.88 v1(160.22,98.8)
  TOP w0.508: 158.58,109.23 PR38.1 ; 158.58,109.23 158.56,109.23 158.11,108.78 ; 158.58,109.23 158.58,108.87 ; 158.58,109.23 158.59,109.23 158.95,108.87
  BOTTOM w0.203: v1(160.22,98.8) 160.11,98.91 PR58.2 ; 168.12,98.34 166.78,97.01 U6.12
  BOTTOM w0.508: v2(160.49,103) 160.5,103.01 160.5,103.65 160.82,103.97 162.73,103.97 164.02,102.68 165.33,102.68 PC50.2 166.15,102.29 166.65,102.78 167.67,102.78 168.12,102.34 168.12,98.34
RT6543A_UG: length 18
  TOP w0.508: v2(159.62,109.87) 159.62,110.6 PR36.1
  ART06 w0.508: v2(159.62,109.87) 159.62,106.73 159.77,106.58 159.77,102.25 164.19,97.83 166.36,97.83 v2(166.39,97.86)
  BOTTOM w0.203: 166.32,97.7 U6.11
  BOTTOM w0.508: v2(166.39,97.86) 166.39,97.76 166.32,97.7
RT6543A_VSEN: length 11.2
  BOTTOM w0.203: PR62.2 160.23,101.47 PR64.2 ; U6.8 164.85,100.09 165.25,100.49 165.25,101.76 164.88,102.12 163.97,102.12 163.61,101.77 163.61,101.37 163.2,100.95
  BOTTOM w0.305: PR108.2 159.19,101.25 PR62.2 ; 163.2,100.95 162.34,100.95 162.19,101.1 162.19,101.19 PR61.2 161.91,101.47 PR64.2
RTA: length 2.8
  BOTTOM w0.305: U37.8 23.77,49.75 23.32,50.2 23.32,50.74 23.6,51.01 R556.2
RTC_RESET: length 120.8
  ART06 w0.102: v1(155.16,53.01) 153.01,53.01 152.27,52.28 146.96,52.28 143.24,56 140,56 139.6,56.4 139.6,57.28 133.65,63.23 128.44,63.23 127.53,64.14 118.47,64.14 117.26,65.36 115.37,65.36 115.02,65 108.45,65 108.1,65.36 106.38,65.36 105.64,66.1 100.43,66.1 99.79,65.46 89.61,65.46 87.61,63.46 79,63.46 77.34,65.13 73.83,65.13 73.07,64.37 63.58,64.37 63.19,63.98 v1(63.06,63.98)
  BOTTOM w0.102: v1(155.16,53.01) 154.69,53.01 154.22,52.55 Q10.1 154.22,50.33 154.01,50.12 152.72,50.12 152.51,49.91 Q7.1 ; v1(63.06,63.98) 63,63.91 63,62.23 62.28,61.52 60.77,61.52 59.58,62.7 59.58,65.43 59.29,65.72 58.15,65.72 R335.2 56.83,66.05 U9.122
RTC_RST#: length 34.6
  TOP w0.076: U1.DT47 169.62,63.34 169.41,63.14 169.41,62.84 169.28,62.7 168.8,62.7 168.76,62.69 168.38,62.31 167.59,62.31 v1(167.17,62.74)
  ART03 w0.305: v1(155.32,46.14) 156.45,46.14 157.15,46.83 157.15,49.21 158.05,50.11 158.05,51.3 158.71,51.96 160.06,51.96 161.73,53.63 162.47,53.63 164.75,55.91 164.75,57.48 165.99,58.72 167.34,58.72 167.93,59.31 167.93,61.84 167.17,62.6 v1(167.17,62.74)
  BOTTOM w0.305: PR13.1 154.76,45.81 155.09,46.14 v1(155.32,46.14) ; R25.1 167.91,64.78 C14.1 168.2,64.77 168.47,64.5 168.47,63.56 168.26,63.36 167.79,63.36 v1(167.17,62.74)

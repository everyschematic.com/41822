# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RTC_X1: length 8.8
  TOP w0.076: U1.DL48 172.36,62.77 172.36,62.37 172.1,62.11 172.1,61.31 170.89,60.09 170.37,60.09 v1(170.13,60.33)
  BOTTOM w0.203: X4.2 173.09,59.69 C47.1 171.89,59.75 R21.2 170.72,59.75 v1(170.13,60.33)
RTC_X2: length 9.6
  TOP w0.076: U1.DL49 172.34,62.1 172.34,61.23 170.88,59.78 169.79,59.78 v1(169.69,59.87)
  BOTTOM w0.203: v1(169.69,59.87) 169.91,59.87 170.98,58.8 R21.1 171.22,58.87 C46.1 172.94,58.87 X4.1
S3_DISCHARGE: length 319
  TOP w0.203: R803.2 82.56,69.56 82.8,69.31 82.8,68.17 84.94,66.03 v1(84.94,65.55) 83.59,64.19 83.59,58.7 81.29,56.4 v1(81.29,53.73) ; Q80.1 85.69,70.87 85.16,70.34 82.32,70.34 R795.1 ; v1(146.39,83.69) 144.78,85.29 121.55,85.29 119.89,86.94 119.89,95.71 120.17,95.99 120.17,110.01 119.97,110.5 119.97,113.97 121.02,115.02 v1(122.17,115.02)
  TOP w0.254: Q79.3 80.64,70.94 81.09,70.49 R795.1 R803.2
  TOP w0.305: Q85.1 233.24,101.83 233.45,101.63 v1(233.45,99.68)
  ART03 w0.203: v1(132.6,74.36) 132.6,80.9 135.76,84.06 146.02,84.06 v1(146.39,83.69)
  ART06 w0.203: v1(81.29,53.73) 82.47,54.9 99.62,54.9 100.97,56.25 104.04,56.25 104.76,55.53 104.76,54.98 v1(103.96,54.18) ; v1(233.45,99.68) 229.03,95.27 191.22,95.27 188.94,97.55 182.21,97.55 173.08,106.68 170.3,106.68 163.92,113.07 137.89,113.07 137.31,112.49 134.84,112.49 132.54,114.79 122.4,114.79 v1(122.17,115.02) ; v1(128.96,65.21) 125.87,65.21 125.82,65.15 118.94,65.15 117.21,66.88 106.14,66.88 105.95,67.08 86.48,67.08 v1(84.94,65.55)
  BOTTOM w0.203: v1(146.39,83.69) 146.39,84.67 146.81,85.09 148.52,85.09 149.14,85.71 Q84.1 ; v1(128.96,65.21) 129.53,65.21 129.73,65.41 Q81.1 129.73,66.63 132.05,68.94 132.05,73.81 v1(132.6,74.36) ; v1(103.96,54.18) 104.5,53.64 Q83.1
S4_DISCHARGE: length 91
  TOP w0.254: Q77.3 80.64,74.85 80.65,74.85 81.21,74.85 ; v1(82.86,72.73) 82.28,73.31 R802.2 R793.1
  TOP w0.305: 81.21,74.85 81.51,74.85 R793.1
  ART06 w0.305: v1(141.33,59.3) 140.96,59.3 138.82,61.44 136.52,61.44 132.82,65.14 130.73,65.14 129.17,66.7 129.17,69.41 130.4,70.64 130.4,75.98 126.85,79.52 123.98,79.52 122.94,78.48 121.9,78.48 121.55,78.82 121.55,78.97 117.49,83.04 96.15,83.04 95.42,82.3 90.14,82.3 88.03,80.2 88.03,75.46 85.31,72.73 v1(82.86,72.73)
  BOTTOM w0.203: Q78.1 143.28,59.79 142.79,59.3 v1(141.33,59.3)
SA0_DIM0: length 19.8
  TOP w0.254: CN11.256 224.97,29.57 225.5,29.05 227.98,29.05 228.58,29.65 v1(228.58,29.98)
  BOTTOM w0.102: R740.1 R738.1 222.22,28.24 222.43,28.44 222.43,31.61 222.83,32.02 225.9,32.02 226.47,31.44 226.47,30.66 226.92,30.21 228.34,30.21 v1(228.58,29.98)
SA0_DIM1: length 6
  TOP w0.254: CN19.256 224.97,18.42
  TOP w0.305: 224.97,18.42 225.11,18.29 v1(225.11,17.76)
  BOTTOM w0.102: v1(225.11,17.76) 224.71,17.76 224.17,17.23 223.43,17.23 R290.1 R292.1
SA1_DIM0: length 15.1
  TOP w0.254: CN11.260 225.97,31.23 226.47,30.73 v1(227.31,30.73)
  BOTTOM w0.102: v1(227.31,30.73) 227.31,31.02 225.96,32.37 222.58,32.37 221.43,31.22 221.43,29.42 220.95,28.93 220.19,28.93 219.5,28.24 R735.1 218.39,28.24 R737.1
SA1_DIM1: length 5.3
  TOP w0.254: CN19.260 225.97,20.06 225.97,20.06 225.97,19.56 v1(226.08,19.45)
  BOTTOM w0.102: v1(226.08,19.45) 225.38,20.16 R289.1 223.25,20.15 R241.1
SATA_RXN1_C: length 4.4
  TOP w0.109: CN9.S5 16.35,46.83 19.64,46.83 C453.2
SATA_RXP1_C: length 4.4
  TOP w0.109: CN9.S6 16.38,47.05 19.63,47.05 C454.2
SATA_TXN1_C: length 4.4
  TOP w0.109: C452.2 19.59,43.21 16.41,43.21 CN9.S3
SATA_TXP1_C: length 4.4
  TOP w0.109: C451.2 19.6,43 16.33,43 CN9.S2
SCL_CONN: length 17.8
  TOP w0.109: CN3.15 v1(58.57,96.31)
  BOTTOM w0.102: v1(58.57,96.31) 58.98,96.71 D16.3 ; Q1.3 60.1,87.17 R444.2
  BOTTOM w0.109: v1(58.57,96.31) 58.57,95.21 57.51,94.15 57.51,86.87 57.92,86.47 59.15,86.47 59.92,87.24 R444.2
SD3_RCOMP: length 1.4
  TOP w0.203: U1.CJ43 183.53,65.41 v1(183.98,65.19)
  BOTTOM w0.102: R279.2 183.98,64.6 v1(183.98,65.19)
SD_RCOMP: length 1.4
  TOP w0.076: U1.CV38 v1(179.4,67.73)
  BOTTOM w0.075: v1(179.4,67.73) 179.39,67.75 R282.2
SDA_CONN: length 17.8
  TOP w0.109: v1(59.29,95.94) 59.16,95.81 CN3.16
  BOTTOM w0.102: R445.2 60.91,89.99 Q2.3 61.76,90.53 62.02,90.79 62.02,92.4 61.92,92.5 61.72,92.5 61.62,92.4 61.62,91.45 61.51,91.35 61.31,91.35 61.21,91.45 61.21,92.4 61.11,92.5 60.9,92.5 60.8,92.4 60.8,91.45 60.7,91.35 60.5,91.35 60.4,91.45 60.4,92.95 61.41,93.96
  BOTTOM w0.109: v1(59.29,95.94) 59.29,95.22 60.23,94.29 61.08,94.29 61.41,93.96 D4.3
SLPS3#_CONTROL: length 30.2
  TOP w0.254: R789.2 94.06,71.43 v1(94.64,70.85)
  ART06 w0.203: v1(117.37,68.56) 117.16,68.76 97.49,68.76 95.4,70.85 v1(94.64,70.85)
  BOTTOM w0.305: R465.2 118.58,69.34 117.81,69.34 117.36,68.9 117.36,68.75 117.37,68.75 v1(117.37,68.56) 117.37,68.15 R196.2 117.15,67.92 117.15,67.01 Q69.3
SM_INTRUDER#: length 9.8
  TOP w0.076: U1.DR47 170.84,64.02 v1(170.73,64.13)
  ART03 w0.102: v1(163.99,65.07) 164.07,65.07 164.57,64.57 170.29,64.57 v1(170.73,64.13)
  BOTTOM w0.075: v1(170.73,64.13) 170.72,64.11 R839.1
  BOTTOM w0.127: R71.1 164.53,65.61 v1(163.99,65.07)
SMB_CLK: length 18.5
  TOP w0.076: U1.DK27 v1(172.86,73.05)
  TOP w0.109: v1(159.43,71.46) 159.36,71.53 R632.2 158.31,71.53 157.46,70.68 Q19.3
  ART03 w0.087: v1(159.43,71.46) 159.43,71.93 159.75,72.25 161.75,72.25 161.77,72.27 163.35,72.27 164.21,73.14 165.49,73.14 166.53,72.1 169.49,72.1 169.65,72.26 170.09,72.26 170.45,72.62 172.43,72.62 v1(172.86,73.05)
SMB_CLK_S2: length 213.7
  TOP w0.109: 154.05,69.91 154.05,67.85 154.56,67.34 154.56,64.96 159.56,59.96 v1(159.56,58.83) ; 154.05,69.91 154.65,69.31 Q19.2 ; 154.05,69.91 R635.1 v1(153.35,69.98) ; CN19.253 224.22,14.43 224.84,15.04 226.59,15.04 v1(226.63,15.01) ; CN22.60 134.34,93.86 134.82,94.34 v1(134.82,94.98) ; CN11.253 224.22,24.05 224.22,25.97 224.84,26.58 227.03,26.58 v1(227.57,26.04)
  ART03 w0.102: v1(159.56,58.83) 159.56,58.59 161.33,56.81 161.33,55.57 158.95,53.19 157.8,53.19 156.68,52.06 156.68,50.68 156,50.01 156,47.35 v1(155.85,47.2)
  ART06 w0.087: v1(227.57,26.04) 228.33,25.28 228.33,20.98 225.83,18.48 225.83,15.8 v1(226.63,15.01) 224.91,13.29 158.37,13.29 156.91,14.74 156.91,17.14 158.02,18.25 158.02,26.15 157.03,27.14 157.03,29.04 157.93,29.95 157.93,34.06 158.62,34.74 158.62,42.91 156.29,45.24 156.29,46.75 v1(155.85,47.2) ; 149.34,73.08 150.86,71.56 151.78,71.56 v1(153.35,69.98) ; v1(134.82,94.98) 134.79,95 134.79,95.21 132.42,97.58 132.42,99.91 133.45,100.94 139.95,100.94 140.43,100.46 140.43,98.21 146.9,91.74 146.9,85.52 147.64,84.78 147.64,80.57 148.53,79.68 148.53,77.9
  ART06 w0.102: 148.53,77.9 148.53,77.75 149.06,77.22 149.06,73.36 149.34,73.08
SMB_DATA: length 18.1
  TOP w0.076: U1.DP24 170.94,74.07 170.94,72.99 v1(170.95,72.97)
  TOP w0.109: v1(159.37,72.98) 159.47,72.88 159.47,72.52 159.31,72.35 R633.2 158.45,72.35 158.05,72.75 157.89,72.75 157.71,72.57 157.57,72.57 157.44,72.7 157.44,72.92 157.58,73.06 157.58,73.22 157.46,73.34 Q27.3
  ART03 w0.087: v1(170.95,72.97) 170.41,72.97 170.06,72.63 169.17,72.63 168.9,72.36 166.98,72.36 166.02,73.32 164.03,73.32 163.47,72.75 161.59,72.75 161.48,72.64 159.69,72.64 159.37,72.95 v1(159.37,72.98)
SMB_DATA_S2: length 223.8
  TOP w0.109: v1(158.73,58.83) 158.73,58.87 158.66,58.93 158.66,60.2 154.02,64.84 154.02,67.13 152.87,68.29 152.87,70.21 v1(153.33,70.67) 153.18,70.81 153.18,72.17 153.69,72.67 R634.1 154.01,72.65 Q27.2 ; v1(134.26,94.97) 134.26,94.53 134.09,94.36 CN22.58 ; v1(226.69,15.68) 226.55,15.54 225.41,15.54 224.47,16.47 CN19.254 ; v1(227.85,26.52) 227.3,27.08 225.41,27.08 224.47,28.01 CN11.254
  ART03 w0.102: v1(158.73,58.83) 158.74,58.83 158.74,58.75 160.44,57.06 160.44,55.55 158.57,53.68 157.53,53.68 156.16,52.32 156.16,50.81 155.57,50.22 155.57,47.75 v1(155.38,47.56)
  ART06 w0.087: v1(134.26,94.97) 131.99,97.24 131.99,100.08 133.24,101.34 140.16,101.34 140.86,100.63 140.86,98.38 147.42,91.82 147.42,85.82 148.12,85.13 148.12,81.06 149.02,80.15 149.02,78.37 ; v1(153.33,70.67) 151.81,72.19 150.88,72.19 149.87,73.2 ; v1(155.38,47.56) 155.38,46.92 155.77,46.54 155.77,44.95 158.02,42.7 158.02,35.01 157.53,34.52 157.53,30.11 156.5,29.09 156.5,26.65 157.32,25.84 157.32,18.36 156.23,17.27 156.23,14.86 158.2,12.89 226.09,12.89 227.55,14.34 227.55,15.26 227.14,15.68 v1(226.69,15.68) 226.28,16.09 226.28,17.87 228.88,20.46 228.88,25.49 v1(227.85,26.52)
  ART06 w0.102: 149.87,73.2 149.54,73.53 149.54,77.45 149.02,77.97 149.02,78.37
SMB_L1CLK_PCH: length 128.2
  TOP w0.076: U1.DN22 v1(171.52,74.83)
  TOP w0.109: R647.2 v1(160.24,75.34)
  ART03 w0.087: v1(171.52,74.83) 171.51,74.83 171.15,74.47 170.63,74.47 170.44,74.66 168.57,74.66 167.68,75.55 161.98,75.55 161.79,75.74 160.64,75.74 v1(160.24,75.34) 159.93,75.65 159.03,75.65 157.3,73.92 154.05,73.92 153.92,74.04 153.05,74.04 152.43,73.42 149.23,73.42 147.88,72.07 144.65,72.07 143.19,70.62 137.87,70.62 134.21,66.95 127.92,66.95 124.22,63.25 120.92,63.25 120.19,62.52 119.17,62.52 117.54,60.9 112.63,60.9 112.14,60.41 109.07,60.41 108.61,60.87 100.21,60.87 99.64,60.3 81.54,60.3 80.25,61.59 75.44,61.59 73.92,63.11 72.02,63.11 71.41,62.5 68.8,62.5 68.26,63.04 63.21,63.04 62.79,63.46 61.43,63.46 v1(60.76,64.14)
  BOTTOM w0.109: v1(60.76,64.14) 60.56,64.34 60.56,68.23 59.47,69.32 R126.1
SMB_L1DATA_PCH: length 129
  TOP w0.075: U1.DL22 172.52,75.19 v1(172.14,74.81)
  TOP w0.109: v1(159.56,75.25) 160.25,74.57 R648.2
  ART03 w0.087: v1(60.96,62.58) 61.17,62.37 65.82,62.37 66.06,62.61 67.86,62.61 68.42,62.05 71.87,62.05 72.5,62.68 73.7,62.68 75.18,61.19 80,61.19 81.3,59.9 99.84,59.9 100.35,60.41 108.27,60.41 108.9,59.78 112.28,59.78 112.92,60.42 117.78,60.42 119.3,61.94 120.26,61.94 121.12,62.8 124.46,62.8 128.16,66.5 134.36,66.5 138.08,70.21 143.68,70.21 145.14,71.68 148.09,71.68 149.39,72.98 153.38,72.98 153.9,73.5 157.44,73.5 159.18,75.24 159.55,75.24 v1(159.56,75.25) 159.93,74.89 160.38,74.89 160.75,75.26 167.61,75.26 168.45,74.42 170.35,74.42 170.49,74.29 171.62,74.29 v1(172.14,74.81)
  BOTTOM w0.109: v1(60.96,62.58) 60.25,62.58 60.03,62.81 60.03,66.26 59.34,66.95 R130.1
SMBL0CLK_NFC: length 11.7
  TOP w0.076: U1.DK24 173.18,74.26 173.06,74.11 v1(172.84,73.84)
  TOP w0.102: R637.2 162.83,73.56 v1(162.92,73.47)
  ART03 w0.087: v1(162.92,73.47) 163.27,73.82 166.65,73.82 167.15,73.32 168.96,73.32 169.07,73.22 170.05,73.22 170.54,73.71 172.71,73.71 v1(172.84,73.84)
SMBL0DATA_NFC: length 11.7
  TOP w0.076: v1(173.51,73.97) 173.51,73.97 173.63,74.11 U1.DJ24
  TOP w0.102: R636.2 163.6,73.5 v1(163.57,73.46)
  ART03 w0.087: 163.96,73.53 166.41,73.53 166.82,73.13 168.57,73.13 168.72,72.97 170.08,72.97 170.58,73.47 173.19,73.47 173.51,73.79 v1(173.51,73.97)
  ART03 w0.102: 163.96,73.53 163.64,73.53 v1(163.57,73.46)
SMC_ONOFF#: length 101.4
  TOP w0.102: v1(88.89,111.81) 89.19,112.11 D20.P
  ART03 w0.102: v1(42.26,83.07) 42.26,93.42 46.05,97.21 46.05,107.83 48.79,110.56 59.71,110.56 61.19,112.04 75.45,112.04 76.85,110.64 82.43,110.64 84.44,112.65 88.06,112.65 v1(88.89,111.81)
  ART06 w0.102: v1(52.84,70.37) 52.73,70.26 48.24,70.26 47.84,70.66 46.5,70.66 44.46,72.7 44.46,73.83 43.13,75.16 43.13,76.95 42.03,78.06 42.03,79.47 43.38,80.82 43.38,82.33 42.64,83.07 v1(42.26,83.07)
  BOTTOM w0.102: v1(52.84,70.37) 53.32,70.85 U9.110 57,70.85 57.73,70.12 R835.2
SMC_RUNTIME_SCI#: length 152.9
  TOP w0.075: 168.41,56.64 168.17,56.88 R97.2 165.38,56.64
  TOP w0.076: 171.5,56.81 171.5,57.64 174.3,60.45 174.63,60.45 175.6,61.42 175.6,62.35 175.54,62.52 175.54,62.52 175.5,62.62 175.5,62.79 U1.DE47
  TOP w0.102: 171.5,56.81 170.44,55.75 169.29,55.75 168.41,56.64 ; v1(157.78,54.47) 158.09,54.16 162.43,54.16 163.22,54.94 163.68,54.94 165.38,56.64
  ART03 w0.102: v1(43.56,57.68) 43.72,57.52 45.61,57.52 46.73,58.63 49.27,58.63 49.77,58.13 53.75,58.13 55.57,56.31 64.28,56.31 65.6,57.63 73.92,57.63 75.07,56.48 79,56.48 80.53,54.95 100.98,54.95 102.67,53.26 104.66,53.26 105.53,54.12 110.72,54.12 111.55,54.95 123.69,54.95 124.59,55.84 125.88,55.84 127.93,57.89 132.56,57.89 133.36,58.69 137.41,58.69 138.47,59.75 144.87,59.75 145.41,59.22 149.44,59.22 150.24,58.42 151.34,58.42 155.28,54.47 v1(157.78,54.47)
  BOTTOM w0.102: U9.23 45.36,60.98 44.7,60.31 44.14,60.31 43.6,59.78 43.6,57.71 v1(43.56,57.68)
SMC_SHUTDOWN#: length 70.2
  TOP w0.102: v1(56.6,75.65) 54.05,78.21 52.86,78.21 52.03,79.04 49.93,79.04 49.66,79.31 49.66,81.13 48.69,82.1 48.69,82.72 49.54,83.57 49.54,84.96 v1(49.44,85.06)
  TOP w0.305: Q31.1 R811.2 81.87,105.25 v1(81.55,105.57)
  ART06 w0.102: v1(81.55,105.57) 80.16,106.96 76.04,106.96 74.06,108.93 67.64,108.93 64.86,106.15 64.86,97.34 63.38,95.85 60.59,95.85 57.05,92.31 57.05,87.6 53.91,84.46 50.03,84.46 v1(49.44,85.06)
  BOTTOM w0.102: v1(56.6,75.65) U9.98
SOC_CATERR#: length 8.6
  TOP w0.075: 213.47,87.1 213.49,87.11 215.22,87.11 215.81,87.71 R129.2 216.15,88 217.22,88 217.5,88.28 U13.2
  TOP w0.076: U1.J4 212.91,84.49 213.02,84.6 213.14,84.71 213.14,84.9 213.24,85 213.24,85.29 213.03,85.5 213.03,86.66 213.47,87.1
SOC_THRMTRIP#: length 6.2
  TOP w0.075: 215,85.29 215,85.64 215.05,85.69 ; 218.57,87.6 218.96,87.99
  TOP w0.076: 215.05,85.69 215.05,86.22 215.26,86.43 216.39,86.43 216.64,86.68 217.65,86.68 218.57,87.6 ; U1.E3 215,85.29
  TOP w0.102: 218.96,87.99 R124.2
SPI_HOLD: length 3.8
  TOP w0.102: U49.7 140.82,63.61 142.4,63.61 142.72,63.93 R722.2 143.7,63.93 R726.2
SPI_SCK_R: length 2.9
  TOP w0.102: U49.6 U49_1.6 143.71,62.35 R724.2
SPI_SI_R: length 3
  TOP w0.109: R728.2 142.73,61.4 142.41,61.08 U49_1.5 U49.5
SPI_SO_R: length 2.8
  TOP w0.109: U49.2 U49_1.2 131.41,63.62 R727.2
SPI_WP_R: length 3.6
  TOP w0.102: U49.3 U49_1.3 131.5,62.35 R723.2 131.31,62.15 R725.2
SPK_L+: length 50.9
  TOP w0.203: U25.42 30.39,76.45 v1(30.25,76.3)
  TOP w0.508: R265.1 12.14,111.3 11.73,111.71 v2(11.68,111.71)
  ART03 w0.508: v2(11.68,111.71) 11.97,111.42 15.66,111.42 22.39,104.69 22.39,94.24 26.65,89.98 29.02,89.98 32.89,86.1 32.89,83.52 31.23,81.87 31.23,77.91 30.25,76.92 v1(30.25,76.3)
SPK_L-: length 51.2
  TOP w0.203: U25.43 30.79,76.38 v1(30.86,76.31)
  TOP w0.508: R262.1 12.19,112.42 v2(12.46,112.14)
  ART03 w0.508: v1(30.86,76.31) 30.86,76.48 31.91,77.53 31.91,81.61 33.57,83.28 33.57,86.39 29.35,90.62 26.92,90.62 23.13,94.42 23.13,105 15.89,112.23 12.54,112.23 v2(12.46,112.14)
SPK_R+: length 241.5
  TOP w0.203: U25.45 31.59,76.82 32.18,76.24 v1(32.18,75.95)
  TOP w0.508: R268.1 225.81,113.92 v2(226.08,114.19)
  ART03 w0.508: v1(32.18,75.95) 33.17,76.94 33.17,81.29 34.64,82.76 34.64,86.68 33.6,87.73 33.6,106.88 33.37,107.11 33.37,109.78 37.29,113.7 75.96,113.7 77.57,112.1 81.45,112.1 83.49,114.14 89.12,114.14 90.2,113.05 109.97,113.05 110.83,113.91 123.57,113.91 124.26,114.6 132.81,114.6 135.14,112.28 136.7,112.28 138.63,114.21 149.2,114.21 149.74,114.74 152.48,114.74 153.01,114.21 176.62,114.21 178.49,112.34 180.03,112.34 180.72,113.03 184.47,113.03 185.19,112.3 195.52,112.3 197.31,110.51 217.44,110.51 221.53,114.6 224.34,114.6 224.78,115.03 225.52,115.03 226.08,114.47 v2(226.08,114.19)
SPK_R-: length 241.2
  TOP w0.203: U25.44 31.19,76.7 31.49,76.41 v1(31.49,76.01)
  TOP w0.508: R267.1 224.6,113.73 v2(225.09,114.23)
  ART03 w0.508: v1(31.49,76.01) 31.49,75.67 31.9,75.26 32.38,75.26 33.9,76.77 33.9,81.11 35.31,82.53 35.31,86.93 34.21,88.04 34.21,107.19 33.98,107.42 33.98,109.51 37.55,113.07 75.61,113.07 77.25,111.43 81.84,111.43 83.9,113.49 88.74,113.49 89.85,112.38 110.25,112.38 111.1,113.22 124.05,113.22 124.79,113.96 132.48,113.96 134.78,111.67 137.01,111.67 138.94,113.59 149.59,113.59 150.1,114.1 152.01,114.1 152.52,113.59 176.37,113.59 178.24,111.72 180.31,111.72 180.99,112.4 184.12,112.4 184.85,111.66 195.24,111.66 197.04,109.86 217.78,109.86 221.87,113.95 224.82,113.95 v2(225.09,114.23)
SRTCRST#: length 26.1
  TOP w0.076: U1.DK46 172.96,63.7 172.96,63.1 172.92,62.98 172.84,62.84 172.84,62.84 172.84,62.78 172.85,62.58 172.88,62.5 172.88,62.16 172.6,61.89 172.6,61.23 170.83,59.46
  TOP w0.102: v1(167.13,59.46) 170,59.46 170.12,59.34 170.71,59.34 170.83,59.46
  ART03 w0.203: v1(154.91,56.92) 155.29,56.92 157.69,59.32 159.7,59.32 160.74,58.28 161.86,58.28 162.79,59.2 166.88,59.2 v1(167.13,59.46)
  BOTTOM w0.203: v1(154.91,56.92) 154.91,56.57 PR71.1
  BOTTOM w0.406: R27.1 167.08,58.62 C15.1 167.11,59.43 v1(167.13,59.46)
SSD_CLK_REQ#: length 94.7
  TOP w0.075: v1(164.33,71) 164.13,71.2 R30.2
  TOP w0.076: U1.DK33 172.86,70.31 v1(172.86,70.31)
  TOP w0.102: CN10.52 100.33,61.45 95.94,61.45 94.83,60.33 v1(94.83,59.15)
  ART03 w0.102: v1(94.83,59.15) 95.15,59.47 99.14,59.47 99.65,58.97 101.17,58.97 101.45,59.24 105.7,59.24 106.54,58.4 107.89,58.4 108.52,57.77 112.37,57.77 112.77,58.17 114.56,58.17 114.98,58.59 120.13,58.59 122.37,60.83 122.54,60.83 124.23,60.83 124.45,61.06 127.18,61.06 130.79,64.67 131.11,64.67 131.56,64.21 134.99,64.21 139.11,68.34 140.34,68.34 141.06,67.62 148.96,67.62 151.16,69.82 151.79,69.82 153.04,71.07 156.17,71.07 156.2,71.04 159.6,71.04 159.69,71.13 162.1,71.13 162.19,71.04 164.28,71.04 v1(164.33,71) 165.07,70.26 171,70.26 171.41,70.67 172.5,70.67 v1(172.86,70.31)
SSD_PCIE_CLK_DN: length 142.3
  TOP w0.076: U1.CJ3 183.52,84.82 183.76,85.37 183.76,85.62 183.74,85.65 183.73,85.87 183.79,86.08 183.79,86.44 183.64,86.58 183.64,88.19 183.84,88.39 183.97,88.39 v1(184.25,88.67)
  TOP w0.109: v1(99.46,75.24) 99.85,74.86 101.17,74.86 102.18,73.84 102.18,67.21 104.49,64.9 104.49,61.63 105.19,60.94 106.89,60.94 107.17,61.22 CN10.53
  ART03 w0.075: 183.54,96.75 183.54,90.09 183.83,89.8 183.83,88.5 183.9,88.43 184.01,88.43 v1(184.25,88.67)
  ART03 w0.087: 183.54,96.75 183.54,99.71 181.27,101.98 178.04,101.98 177.68,102.35 174.41,102.35 173.72,103.04 163.63,103.04 162.94,103.73 151.06,103.73 150.63,103.3 144.06,103.3 141.83,101.07 130.74,101.07 128.19,103.62 125.97,103.62 125.63,103.28 118.15,103.28 104.64,89.77 104.64,84.88 100,80.23 100,75.05 99.89,74.94 99.77,74.94 v1(99.46,75.24)
SSD_PCIE_CLK_DP: length 142.3
  TOP w0.076: U1.CJ5 183.77,84.52 183.82,85.1 183.92,85.34 183.92,85.66 183.9,85.69 183.89,85.85 183.96,86.05 183.96,86.5 183.81,86.65 183.81,88.12 183.91,88.23 184.06,88.23 v1(184.25,88.03)
  TOP w0.109: v1(99.46,74.64) 101.07,74.64 101.96,73.75 101.96,67.12 104.27,64.81 104.27,61.54 105.1,60.72 CN10.55
  ART03 w0.075: v1(184.25,88.03) 184.01,88.28 183.84,88.28 183.68,88.44 183.68,89.74 183.39,90.03 183.39,96.68 183.39,96.68 183.39,96.73 183.38,96.73 183.38,97.55 183.36,97.57
  ART03 w0.087: 183.36,97.57 183.36,99.64 181.2,101.8 177.97,101.8 177.6,102.17 174.33,102.17 173.64,102.86 163.55,102.86 162.86,103.55 151.13,103.55 150.7,103.12 144.14,103.12 141.9,100.88 130.66,100.88 128.11,103.43 126.04,103.43 125.71,103.1 118.22,103.1 104.82,89.7 104.82,84.8 100.18,80.16 100.18,74.97 99.96,74.75 99.58,74.75 v1(99.46,74.64)
SSD_PCIE_WAKE#: length 3
  TOP w0.102: CN10.54 R223.2
SSD_PEDET: length 85.1
  TOP w0.076: U1.CR42 v1(181.23,65.83)
  TOP w0.102: R364.1 113.62,61.59 113.62,60.15 v1(113.76,60)
  ART06 w0.102: v1(181.23,65.83) 181.23,64.2 175.12,58.09 174.39,58.09 172.11,55.81 172.11,53.79 166.83,48.5 153.78,48.5 153.59,48.31 151.04,48.31 149.29,50.07 146.69,50.07 142.68,54.08 139.09,54.08 133.41,59.76 125.06,59.76 123.51,61.31 118.96,61.31 117.55,59.9 113.87,59.9 v1(113.76,60)
SSD_SATA_DEVSLP: length 85.7
  TOP w0.075: 167.59,80.7 169.48,80.7 U1.DU11
  TOP w0.076: 164.72,81.33 164.72,81.18 164.92,80.98 167.31,80.98 167.59,80.7
  TOP w0.102: v1(156.51,81.91) 156.51,81.87 156.94,81.44 157.07,81.38 ; R901.1 98.56,63.52 99.05,64.01 99.05,66.42 v1(99.15,66.52)
  TOP w0.109: 164.72,81.33 164.47,81.58 163.27,81.58 162.95,81.9 159.45,81.9 158.93,81.38 157.07,81.38
  ART03 w0.102: v1(99.15,66.52) 99.93,67.3 111.79,67.3 113.83,69.34 119.13,69.34 124.95,75.16 124.95,76.53 128.3,79.89 129.37,79.89 134.78,85.29 144.72,85.29 145.08,85.65 149.64,85.65 149.74,85.56 152.74,85.56 156.39,81.91 v1(156.51,81.91)
SSD_SATA_RXN1: length 230.3
  TOP w0.076: U1.CA6 v1(187.89,83.68)
  TOP w0.109: v1(29.63,64.81) 29.24,64.43 29.24,62.62 27.52,60.9 27.52,54.6 22.91,49.99 22.91,47.25 22.21,46.55 C453.1
  ART03 w0.075: 187.26,97.57 187.26,97.55 187.28,97.54 187.28,91.29 186.09,90.11 186.09,87.92 186.92,87.09 186.92,85.52 187.28,85.17 187.28,84.09 187.44,83.93 187.65,83.93 v1(187.89,83.68)
  ART03 w0.087: v1(29.63,64.81) 29.28,65.16 29.28,65.56 32.27,68.55 32.27,70.39 33.61,71.72 35.95,71.72 36.57,72.34 36.57,73.83 37.77,75.03 47.73,75.03 48.64,74.11 54.07,74.11 54.29,74.34 55.68,74.34 56.44,75.09 57.48,75.09 58.08,75.69 59.41,75.69 59.78,76.05 63.66,76.05 64.87,77.26 80.29,77.26 80.7,77.67 85.38,77.67 87.78,75.28 91.21,75.28 102.33,86.4 102.33,90.09 117.18,104.94 123.54,104.94 124.26,105.65 128.46,105.65 131.42,102.69 139.54,102.69 140.14,103.29 140.14,104.02 141.77,105.66 149.56,105.66 149.92,106.02 164.81,106.02 165.44,106.65 167,106.65 167.58,106.06 173.93,106.06 175.29,104.7 184.28,104.7 187.26,101.72 187.26,97.57
SSD_SATA_RXP1: length 230.3
  TOP w0.076: U1.CA5 v1(187.89,84.32)
  TOP w0.109: v1(29.02,64.81) 29.02,62.71 27.3,60.99 27.3,54.69 22.69,50.08 22.69,47.34 22.12,46.77 21.71,46.77 21.5,46.98 21.5,47.06 21.21,47.35 C454.1
  ART03 w0.075: v1(187.89,84.32) 187.65,84.08 187.5,84.08 187.43,84.15 187.43,85.23 187.07,85.59 187.07,87.15 186.24,87.98 186.24,90.04 187.43,91.23 187.43,97.54 187.45,97.55 187.45,97.57
  ART03 w0.087: 187.45,97.57 187.45,101.8 184.36,104.89 175.36,104.89 174,106.25 167.66,106.25 167.07,106.83 165.36,106.83 164.74,106.2 149.84,106.2 149.48,105.84 141.69,105.84 139.95,104.1 139.95,103.36 139.46,102.87 131.49,102.87 128.53,105.83 124.18,105.83 123.47,105.12 117.1,105.12 102.15,90.17 102.15,86.48 91.14,75.46 87.85,75.46 85.46,77.86 80.62,77.86 80.21,77.44 64.79,77.44 63.59,76.24 59.7,76.24 59.33,75.87 58,75.87 57.41,75.27 56.36,75.27 55.61,74.52 54.22,74.52 53.99,74.29 48.72,74.29 47.8,75.21 37.69,75.21 36.39,73.91 36.39,72.41 35.88,71.91 33.53,71.91 32.09,70.46 32.09,68.63 29.1,65.64 29.1,64.89 v1(29.02,64.81)
SSD_SATA_TXN1: length 224.5
  TOP w0.076: v1(181.5,89.94) 181.26,89.94 181.18,90.02 181.18,90.33 181.12,90.4 180.8,90.4 180.69,90.28 180.69,89.89 180.77,89.82 180.9,89.82 180.98,89.74 180.98,89.59 180.9,89.51 180.77,89.51 180.69,89.43 180.69,89.28 180.77,89.21 180.83,89.21 180.92,89.12 180.92,88.99 180.83,88.9 180.77,88.9 180.69,88.82 180.69,85.88 180.8,85.77 180.95,85.77 181.03,85.85 U1.CP1
  TOP w0.109: C452.1 21.11,43.23 21.35,43.23 v1(21.53,43.41)
  ART03 w0.075: 180.72,97.57 180.72,97.55 180.74,97.54 180.74,90.5 181.06,90.18 181.26,90.18 v1(181.5,89.94)
  ART03 w0.087: v1(21.53,43.41) 21.32,43.2 21.06,43.2 20.24,44.03 20.24,52.41 27.75,59.92 27.75,61.65 32.3,66.2 32.63,66.2 33.65,67.23 33.65,68.28 33.13,68.81 33.13,70.2 33.99,71.06 36.22,71.06 38.79,73.63 44.15,73.63 45.51,72.28 47.41,72.28 48.21,73.07 54.02,73.07 54.6,73.65 58.45,73.65 59.34,74.54 59.9,74.54 60.26,74.9 64.52,74.9 65.65,76.03 67.9,76.03 68.69,75.25 79.21,75.25 80.58,73.88 84.73,73.88 85.81,72.79 100.4,72.79 101.56,73.95 101.56,77.98 107.18,83.6 107.18,90.11 118.83,101.77 127.45,101.77 127.84,101.38 128.3,101.38 130.11,99.57 133.85,99.57 134.4,99.02 145.6,99.02 146.07,99.49 148.38,99.49 149.37,100.47 151.66,100.47 152.33,101.14 158.08,101.14 158.21,101 162.37,101 162.75,100.62 163.54,100.62 164.08,100.07 168.52,100.07 168.59,100.14 176.56,100.14 176.91,99.8 179.46,99.8 180.72,98.53 180.72,97.57
SSD_SATA_TXP1: length 224.6
  TOP w0.076: U1.CP2 180.9,85.59 180.73,85.59 180.51,85.81 180.51,90.36 180.73,90.57 v1(181.5,90.57)
  TOP w0.109: v1(21.53,42.81) 21.32,43.01 21.13,43.01 C451.1
  ART03 w0.075: v1(181.5,90.57) 181.26,90.33 181.13,90.33 180.89,90.56 180.89,97.55 180.91,97.56 180.91,97.57
  ART03 w0.087: v1(21.53,42.81) 21.32,43.02 20.99,43.02 20.06,43.95 20.06,52.49 27.57,59.99 27.57,61.73 32.23,66.38 32.55,66.38 33.47,67.3 33.47,68.21 32.95,68.73 32.95,70.28 33.92,71.25 36.14,71.25 38.71,73.82 44.23,73.82 45.59,72.46 47.34,72.46 48.14,73.26 53.94,73.26 54.52,73.84 58.38,73.84 59.26,74.72 59.82,74.72 60.19,75.09 64.45,75.09 65.58,76.21 67.98,76.21 68.76,75.43 79.28,75.43 80.65,74.06 84.8,74.06 85.89,72.97 100.32,72.97 101.37,74.02 101.37,78.05 106.99,83.67 106.99,90.19 118.76,101.95 127.52,101.95 127.91,101.56 128.37,101.56 130.19,99.75 133.93,99.75 134.48,99.2 145.53,99.2 145.99,99.67 148.3,99.67 149.29,100.65 151.58,100.65 152.25,101.32 158.15,101.32 158.29,101.19 162.41,101.19 162.82,100.78 163.61,100.78 164.15,100.24 168.46,100.24 168.52,100.3 176.56,100.3 176.58,100.32 176.64,100.32 176.99,99.98 179.54,99.98 180.91,98.61 180.91,97.57
SSTCMP: length 1.7
  BOTTOM w0.305: R533.1 32.23,45.85 U37.15
STATUS: length 1.9
  BOTTOM w0.305: U37.14 32.27,46.5 R537.1
SUS_CK: length 197.5
  TOP w0.075: v1(170,56.71) 170.02,56.73 170.42,56.73 171.03,57.34 171.03,57.62 174.27,60.86 174.55,60.86
  TOP w0.076: U1.DF49 175.2,62.33 175.2,61.51 174.55,60.86
  TOP w0.109: v1(123.67,86.96) 123.67,87.14 123.22,87.59 122.65,87.59 122.27,87.97 122.27,93.61 124.01,95.35 127.82,95.35 128.31,94.86 R275.1 ; CN10.68 101.5,57.47 v1(101.53,57.45)
  ART03 w0.102: v1(101.53,57.45) 101.48,57.41 98.76,57.41 98.52,57.64 92.99,57.64 92.83,57.48 80.45,57.48 79.53,58.4 77.51,58.4 76.86,59.05 65.74,59.05 65.43,58.74 51.53,58.74 51.13,59.15 46.28,59.15 v1(45.9,58.76)
  ART06 w0.102: v1(170,56.71) 167.72,54.42 164.66,54.42 163.29,55.79 162.76,55.79 162.18,55.21 161.59,55.21 160.27,53.89 157.08,53.89 156.78,54.2 152.2,54.2 151.88,53.87 150.17,53.87 149.69,54.36 146.37,54.36 143.28,57.45 143.28,58.09 138.82,62.55 137.57,62.55 134.64,65.48 134.64,65.62 133.07,67.19 133.07,78.21 124.32,86.96 v1(123.67,86.96)
  BOTTOM w0.109: R911.2 46.15,58.49 45.9,58.74 v1(45.9,58.76) ; v1(101.53,57.45) 101.79,57.71 101.79,58.17 103.65,60.03 103.65,66.63 109.58,72.57 109.58,77.46 113.4,81.28 113.4,86.2 114.09,86.88 116.94,86.88 118.23,85.59 122.31,85.59 v1(123.67,86.96) ; R19.2 v1(170,56.71)
SYNC: length 35.5
  TOP w0.075: 178.9,60.9 175.43,57.43 175.43,54.23 175.24,54.04
  TOP w0.076: U1.CV49 179.08,62.21 179.08,61.49 178.9,61.31 178.9,60.9
  TOP w0.109: 175.24,54.04 172.09,50.89 162.54,50.89 161.44,51.99 154.51,51.99 R627.2 153.02,52.9 R277.2
SYS_PWROK: length 128.8
  TOP w0.076: U1.DP19 v1(170.91,76.71)
  ART03 w0.102: v1(170.91,76.71) 170.59,77.04 170.15,77.04 169.62,77.57 168.38,77.57 167.48,78.47 166.46,78.47 165.79,77.8 164.19,77.8 163.28,78.71 160.21,78.71 159.45,77.95 157.16,77.95 155.59,76.38 148.07,76.38 147.55,76.9 145.4,76.9 144.88,76.38 141.52,76.38 141.1,75.95 141.1,74.73 139.16,72.8 136.99,72.8 134.48,70.29 127.49,70.29 125.5,68.29 125.5,67.28 123.05,64.82 116.53,64.82 115.53,63.83 101.3,63.83 100.19,62.71 81.82,62.71 81.41,63.12 78.58,63.12 76.82,64.89 73.41,64.89 73.1,65.2 64.77,65.2 64.25,65.72 63.23,65.72 62.71,66.23 60.73,66.23 60.04,65.54 59.47,65.54 59.24,65.78 58.34,65.78 56.98,64.41 v1(56.64,64.41)
  BOTTOM w0.102: v1(56.64,64.41) 56.59,64.45 U9.126
  BOTTOM w0.305: R110.1 170.37,77.26 v1(170.91,76.71)
TBCLK: length 7.1
  BOTTOM w0.109: R1399.1 49.12,82.16 49.61,82.65 49.98,82.65 50.44,82.2 50.44,80.88 R138.2 51.63,79.68 51.63,78.58 51.36,78.31 U9.89
TBDATA: length 2.9
  BOTTOM w0.109: R140.2 51.98,80.13 51.98,78.38 51.76,78.16 U9.90
TCRCOMP_DN: length 2
  TOP w0.076: R18.1 197.66,87.81 U1.AY1
TCRCOMP_DP: length 2.9
  TOP w0.075: R18.2 197.97,87.62 197.97,87.2
  TOP w0.076: 197.97,87.2 197.97,85.77 U1.AY2
TLS_CONFIDENTIALITY: length 17.2
  TOP w0.076: v1(172.89,74.76) 172.81,74.76 172.52,74.47 U1.DL24
  TOP w0.102: R179.1 158.81,75.8 R180.2 158.81,75.77 158.81,75.2 v1(159.34,74.67)
  ART03 w0.075: v1(172.89,74.76) 172.73,74.76 172.04,74.07 170.48,74.07 170.33,74.22 168.31,74.22 167.54,75 161.97,75
  ART03 w0.102: v1(159.34,74.67) 159.41,74.6 160.53,74.6 160.93,75 161.97,75
TMDS_CLKN: length 215.9
  TOP w0.076: U1.AC1 205.69,86.47 205.69,88.42 205.44,88.67 205.06,88.67 v1(204.93,88.8)
  TOP w0.109: C374.1 58.85,79.56 v1(58.81,79.53)
  ART03 w0.075: 200.69,97.57 200.69,97.55 200.68,97.54 200.68,97.02 202.72,94.99 202.72,88.72 203.44,87.99 204.04,87.99 204.14,88.1 204.14,88.35 204.45,88.65 204.78,88.65 v1(204.93,88.8)
  ART03 w0.087: 200.69,97.57 200.69,98.27 197.78,101.18 197.4,101.18 190.56,108.03 176.7,108.03 175.38,109.34 168.94,109.34 168.32,109.96 164,109.96 163.38,109.34 159.22,109.34 158.94,109.62 140.25,109.62 138.46,107.83 138.08,107.83 136.74,106.49 134.18,106.49 131.24,109.43 122.8,109.43 122.13,108.76 112.75,108.76 110.88,106.89 86.61,106.89 86.27,106.55 84.15,106.55 83.74,106.95 74.76,106.95 73.39,108.31 68.95,108.31 60.11,99.47 60.11,95.32 55.01,90.22 55.01,87.91 55.21,87.72 56.96,87.72 57.13,87.55 57.13,83.36 57.05,83.27 56.87,83.27 56.79,83.36 56.79,86.97 56.59,87.17 56.27,87.17 56.07,86.97 56.07,83.36 55.99,83.27 55.81,83.27 55.73,83.36 55.73,86.97 55.53,87.17 55.21,87.17 55.01,86.97 55.01,82.41 55.32,82.1 55.32,81.12 57.8,78.65 58.37,78.65 58.61,78.88 58.61,79.33 v1(58.81,79.53)
TMDS_CLKP: length 215.5
  TOP w0.076: v1(204.93,88.2) 205.25,88.52 205.38,88.52 205.54,88.35 205.54,86.41 205.77,86.17 205.77,85.96 206.05,85.68 U1.AC2
  TOP w0.109: C373.1 58.08,79.66 v1(58.21,79.53)
  ART03 w0.075: v1(204.93,88.2) 204.67,88.46 204.47,88.46 204.3,88.28 204.3,88.03 204.11,87.84 203.38,87.84 202.56,88.65 202.56,94.92 200.53,96.96 200.53,97.54 200.51,97.55 200.51,97.57
  ART03 w0.087: v1(58.21,79.53) 58.43,79.31 58.43,78.96 58.3,78.83 57.87,78.83 55.51,81.19 55.51,82.18 55.2,82.49 55.2,86.9 55.28,86.98 55.46,86.98 55.54,86.9 55.54,83.28 55.74,83.09 56.06,83.09 56.26,83.28 56.26,86.9 56.34,86.98 56.52,86.98 56.6,86.9 56.6,83.28 56.8,83.09 57.12,83.09 57.32,83.28 57.32,87.62 57.04,87.9 55.28,87.9 55.2,87.99 55.2,90.14 60.3,95.24 60.3,99.4 69.03,108.13 73.32,108.13 74.68,106.77 83.67,106.77 84.07,106.36 86.34,106.36 86.69,106.71 110.96,106.71 112.83,108.58 122.21,108.58 122.88,109.24 131.16,109.24 134.1,106.31 136.82,106.31 138.16,107.65 138.53,107.65 140.32,109.44 158.86,109.44 159.14,109.15 163.45,109.15 164.08,109.78 168.24,109.78 168.87,109.15 175.31,109.15 176.62,107.84 190.48,107.84 197.33,101 197.7,101 200.51,98.19 200.51,97.57
TMDS_DATAN0: length 213.8
  TOP w0.075: 206.34,85.12 206.46,85.24
  TOP w0.076: U1.AC5 206.05,84.39 206.34,84.68 206.34,85.12 ; 206.46,85.24 206.46,86.37 206.16,86.67 206.16,90.3 205.89,90.57 205.11,90.57 v1(205,90.68)
  TOP w0.109: C372.1 56.26,79.97 v1(56.26,79.42)
  ART03 w0.075: 204.45,97.57 204.46,97.56 204.46,97.54 205.09,96.9 205.09,96.64 205.68,96.05 205.68,92.26 205.17,91.75 204.82,91.75 204.68,91.6 204.68,91.01 v1(205,90.68)
  ART03 w0.087: 204.45,97.57 199.8,102.22 199.8,104.44 194.22,110.01 177.56,110.01 175.65,111.92 139.73,111.92 137.7,109.88 137.21,109.88 135.79,108.46 135,108.46 131.99,111.47 122.07,111.47 121.34,110.74 111.82,110.74 109.94,108.87 101.68,108.87 100.97,109.58 84.65,109.58 84.06,108.99 75.79,108.99 74.48,110.3 66.71,110.3 60.8,104.38 60.17,104.38 54.78,98.99 54.78,96.49 53.13,94.84 53.13,92.47 50.73,90.08 50.73,80.54 49.42,79.23 49.42,78.14 49.67,77.9 55.03,77.9 56.05,78.92 56.05,79.21 v1(56.26,79.42)
TMDS_DATAN1: length 211.6
  TOP w0.076: U1.AE2 204.92,85.7 205.19,85.97 205.19,86.26 204.97,86.48 204.77,86.48 204.52,86.73 204.52,90.51 204.34,90.69 204.08,90.69 v1(203.8,90.96)
  TOP w0.109: v1(53.7,79.48) 53.71,79.49 53.71,79.95 C370.1
  ART03 w0.075: v1(203.8,90.96) 203.97,90.8 204.12,90.8 204.21,90.88 204.21,96.55 203.32,97.43 203.3,97.43 203.28,97.44
  ART03 w0.087: v1(53.7,79.48) 53.52,79.67 53.52,81.18 52.73,81.96 52.73,88.43 52.53,88.62 52.21,88.62 52.02,88.43 52.02,83.26 51.93,83.18 51.76,83.18 51.67,83.26 51.67,89.6 52,89.93 52.84,89.93 55.03,92.12 55.03,92.88 56.64,94.49 56.64,98.99 67.1,109.46 74.08,109.46 75.4,108.15 84.62,108.15 85.21,108.73 100.11,108.73 100.81,108.03 110.31,108.03 112.17,109.89 121.68,109.89 122.41,110.62 131.66,110.62 134.65,107.62 136.16,107.62 137.58,109.05 138.08,109.05 140.11,111.08 162.15,111.08 162.5,110.73 163.19,110.73 163.53,111.08 175.28,111.08 177.19,109.17 193.81,109.17 198.86,104.11 198.86,101.86 203.28,97.44
TMDS_DATAN2: length 208.8
  TOP w0.075: U1.AE3 204.68,84.76 204.68,84.92 204.68,85.04 204.68,85.27 204.67,85.36 204.67,85.4
  TOP w0.076: v1(203.66,89.04) 203.66,88.94 204.18,88.42 204.18,86.51 204.66,86.03 204.68,85.97 204.66,85.69 204.67,85.4
  TOP w0.109: v1(51.17,79.49) 51.17,79.95 C368.1
  ART03 w0.075: v1(203.66,89.04) 203.42,88.8 203.31,88.8 203.17,88.94 203.17,95.37 201.57,96.97 201.57,97.54 201.58,97.55 201.58,97.57
  ART03 w0.087: 201.58,97.57 201.58,98.44 197.97,102.06 197.97,104.09 193.37,108.69 176.98,108.69 175.05,110.61 163.73,110.61 163.38,110.26 162.11,110.26 161.77,110.61 149.78,110.61 149.46,110.29 139.99,110.29 138.25,108.54 137.81,108.54 136.42,107.15 134.45,107.15 131.48,110.12 122.57,110.12 121.86,109.41 112.4,109.41 110.54,107.55 100.5,107.55 99.8,108.24 85.53,108.24 84.96,107.67 75.12,107.67 73.81,108.98 67.75,108.98 59.13,100.37 59.13,98.26 57.2,96.33 57.2,93.61 53.27,89.68 53.27,86.75 53.46,86.56 54.24,86.56 54.33,86.47 54.33,83.59 54.24,83.51 54.07,83.51 53.98,83.59 53.98,86.02 53.79,86.21 53.46,86.21 53.27,86.02 53.27,82.1 54.46,80.91 54.46,79.36 54.06,78.96 51.19,78.96 50.95,79.2 50.95,79.27 v1(51.17,79.49)
TMDS_DATAP0: length 213.6
  TOP w0.075: U1.AC3 206.19,84.95 ; 206.3,85.3 206.19,85.18 206.19,85.14 206.19,85.12
  TOP w0.076: v1(205,90.05) 205.38,90.42 205.83,90.42 206.01,90.24 206.01,89.86 205.93,89.78 205.8,89.78 205.73,89.7 205.73,89.55 205.8,89.47 205.93,89.47 206.01,89.4 206.01,89.25 205.93,89.17 205.8,89.17 205.73,89.09 205.73,88.94 205.8,88.86 205.93,88.86 206.01,88.79 206.01,86.61 206.3,86.31 206.3,85.3 ; 206.19,84.95 206.19,85.12
  TOP w0.109: v1(55.66,79.42) 55.66,79.94 C371.1
  ART03 w0.075: v1(205,90.05) 204.52,90.52 204.52,91.66 204.76,91.9 205.1,91.9 205.53,92.33 205.53,95.99 204.94,96.58 204.94,96.84 204.35,97.43 204.33,97.43 204.32,97.44
  ART03 w0.087: v1(55.66,79.42) 55.87,79.21 55.87,78.99 55.65,78.78 55.53,78.78 55.46,78.85 55.34,78.85 55.21,78.73 55.21,78.6 55.29,78.53 55.29,78.41 54.96,78.08 49.74,78.08 49.6,78.22 49.6,79.15 50.92,80.47 50.92,90 53.31,92.4 53.31,94.76 54.96,96.41 54.96,98.91 60.25,104.2 60.87,104.2 66.79,110.12 74.4,110.12 75.71,108.81 84.14,108.81 84.73,109.4 100.89,109.4 101.6,108.69 110.02,108.69 111.9,110.56 121.42,110.56 122.14,111.29 131.91,111.29 134.93,108.27 135.86,108.27 137.29,109.7 137.78,109.7 139.81,111.73 175.58,111.73 177.48,109.83 194.15,109.83 199.61,104.36 199.61,102.15 204.32,97.44
TMDS_DATAP1: length 211.6
  TOP w0.076: v1(203.8,90.32) 203.99,90.51 204.26,90.51 204.34,90.43 204.34,89.38 204.26,89.3 204.2,89.3 204.13,89.24 204.13,89.07 204.21,89 204.26,89 204.34,88.92 204.34,86.66 204.69,86.3 204.73,86.3 U1.AE1
  TOP w0.109: C369.1 53.11,79.95 53.11,79.49 v1(53.1,79.48)
  ART03 w0.075: 203.42,97.57 203.43,97.56 203.43,97.54 204.36,96.61 204.36,90.82 204.18,90.65 204.13,90.65 v1(203.8,90.32)
  ART03 w0.087: v1(53.1,79.48) 53.33,79.72 53.33,81.1 52.55,81.89 52.55,88.35 52.46,88.44 52.29,88.44 52.2,88.35 52.2,83.19 52.01,82.99 51.68,82.99 51.49,83.19 51.49,89.67 51.92,90.11 52.76,90.11 54.84,92.19 54.84,92.96 56.45,94.56 56.45,99.07 67.03,109.65 74.16,109.65 75.47,108.33 84.54,108.33 85.13,108.91 100.19,108.91 100.89,108.21 110.23,108.21 112.09,110.07 121.6,110.07 122.33,110.8 131.73,110.8 134.73,107.81 136.09,107.81 137.51,109.23 138,109.23 140.03,111.26 162.23,111.26 162.57,110.92 163.11,110.92 163.46,111.26 175.36,111.26 177.27,109.35 193.89,109.35 199.05,104.19 199.05,101.94 203.42,97.57
TMDS_DATAP2: length 209.1
  TOP w0.076: v1(203.66,88.41) 203.75,88.5 203.86,88.5 204,88.35 204,86.44 204.5,85.94 204.52,85.87 204.51,85.69 204.51,85.51 204.51,85.27 204.53,85.26 204.53,85.04 204.53,84.7 204.68,84.55 204.68,84.41 U1.AE5
  TOP w0.109: v1(50.57,79.49) 50.57,79.96 C367.1
  ART03 w0.075: v1(203.66,88.41) 203.42,88.65 203.25,88.65 203.02,88.88 203.02,95.31 201.42,96.91 201.42,97.54 201.4,97.55 201.4,97.57
  ART03 w0.087: v1(50.57,79.49) 50.71,79.35 50.71,79.19 51.11,78.78 54.13,78.78 54.64,79.29 54.64,80.99 53.45,82.18 53.45,85.94 53.54,86.03 53.71,86.03 53.8,85.94 53.8,83.52 53.99,83.32 54.32,83.32 54.51,83.52 54.51,86.55 54.32,86.74 53.54,86.74 53.45,86.83 53.45,89.61 57.38,93.54 57.38,96.25 59.32,98.19 59.32,100.29 67.82,108.8 73.73,108.8 75.04,107.49 85.04,107.49 85.61,108.06 99.73,108.06 100.42,107.37 110.62,107.37 112.47,109.23 121.94,109.23 122.65,109.94 131.4,109.94 134.37,106.97 136.5,106.97 137.89,108.36 138.32,108.36 140.06,110.1 149.53,110.1 149.85,110.42 161.69,110.42 162.03,110.08 163.46,110.08 163.8,110.43 174.97,110.43 176.9,108.5 193.29,108.5 197.78,104.01 197.78,101.98 201.4,98.36 201.4,97.57
TP_CM33: length 1.2
  TOP w0.076: v1(182.41,71.41) 182.41,71.43 182.46,71.43 182.16,71.12 U1.CM33
TP_DB10: length 1.4
  TOP w0.076: v1(175.98,81.82) 176.12,81.67 U1.DB10
  BOTTOM w0.305: TP20.1 175.98,82.23 v1(175.98,81.82)
TP_DH49: length 8.3
  TOP w0.075: 171.52,58.92 170.51,57.92 168.48,57.92 TP25.1
  TOP w0.076: U1.DH49 173.93,61.33 171.52,58.92
TP_DV47: length 2.7
  TOP w0.075: TP21.1 166.67,63.15 167.07,63.15
  TOP w0.076: 167.07,63.15 168.55,63.15 U1.DV47
TP_DW47: length 2.4
  TOP w0.076: TP24.1 166.15,63.56 168.37,63.56 U1.DW47
TP_LTB_CFG_STB1_DP: length 0.5
  TOP w0.076: U1.Y7 v1(208.02,83.03)
TP_MBP1_N: length 0.9
  TOP w0.076: U1.T7 v1(209.9,82.65)
  BOTTOM w0.127: v1(209.9,82.65) 210.09,82.46 TP53.1
TP_MBP2_N: length 0.8
  TOP w0.076: U1.T10 v1(209.85,81.74)
  BOTTOM w0.127: TP54.1 209.82,81.71 v1(209.85,81.74)
TP_MBP3_N: length 1.3
  TOP w0.076: U1.T6 210,83.44 v1(210.22,83.21)
  BOTTOM w0.127: v1(210.22,83.21) 210.01,83.42 TP55.1
TXN0_LVDS: length 3.9
  BOTTOM w0.109: U42.5 56.03,26.38 56.13,26.48 56.64,26.48 57.45,27.29 57.45,28.22 57.62,28.39 58.1,28.39 C152.1
TXN1_LVDS: length 2.8
  BOTTOM w0.109: U42.8 56.18,25.18 56.26,25.27 57.14,25.27 57.39,25.02 57.95,25.02 C154.1
TXP0_LVDS: length 4
  BOTTOM w0.109: C153.1 57.79,28.6 57.53,28.6 57.23,28.31 57.23,27.38 56.55,26.7 56.1,26.7 56.02,26.78 U42.4
TXP1_LVDS: length 2.8
  BOTTOM w0.109: C155.1 57.94,25.24 57.48,25.24 57.23,25.49 56.22,25.49 56.13,25.58 U42.7
UART1_RXD: length 89.4
  TOP w0.075: R653.1 165.32,75.07 TP49.1 165.12,74.94 v1(164.79,74.6)
  TOP w0.076: U1.DW22 167.91,75.71 167.55,76.08 R653.1
  ART03 w0.075: v1(164.79,74.6) 164.54,74.85 162.22,74.85 162.17,74.79 161.97,74.79
  ART03 w0.102: v1(99.87,59.42) 100.34,59.88 106.07,59.88 106.95,59 112.73,59 113.12,59.39 117.31,59.39 119.1,61.17 121.33,61.17 121.81,61.65 123.56,61.65 124.12,62.2 126.7,62.2 130.11,65.61 131.75,65.61 132.27,65.1 134.32,65.1 136.83,67.61 136.83,68.48 138.24,69.88 143.82,69.88 144.69,70.75 147.79,70.75 149.65,72.61 153.53,72.61 153.95,73.03 157.47,73.03 158.72,74.28 160.61,74.28 161.12,74.79 161.97,74.79
  BOTTOM w0.102: J9.2 96.69,50.54 96.69,52.57 100.09,55.96 100.09,59.2 v1(99.87,59.42)
UART1_TXD: length 91.8
  TOP w0.075: v1(165.9,74.52) 165.9,74.35 166.39,73.86 ; 166.39,73.86 166.39,74.91 TP48.1 ; 166.39,73.86 R654.1
  TOP w0.076: TP48.1 167.36,74.96 168.3,75.36 169.09,75.41 170.08,75.41 U1.DT22
  ART03 w0.075: 164.13,74.64 164.25,74.64 164.64,74.25 165.65,74.25 165.9,74.5 v1(165.9,74.52)
  ART03 w0.102: 164.13,74.64 162.56,74.64 162.49,74.56 161.23,74.56 160.72,74.05 158.86,74.05 157.47,72.67 154.03,72.67 153.66,72.29 149.86,72.29 147.97,70.41 144.72,70.41 143.93,69.62 138.44,69.62 137.14,68.32 137.14,67.47 134.55,64.88 131.96,64.88 131.44,65.4 130.3,65.4 126.56,61.67 124.2,61.67 123.97,61.44 122.79,61.44 122.12,61.44 121.6,60.93 119.27,60.93 117.13,58.79 114.9,58.79 114.48,58.38 109.57,58.38 109.21,58.74 106.89,58.74 106.06,59.57 100.86,59.57 v1(100.75,59.46)
  BOTTOM w0.102: v1(100.75,59.46) 100.42,59.14 100.42,55.72 97.08,52.38 97.08,50.66 J9.1
UGATE1: length 38
  TOP w0.508: v2(199.15,106.41) 199.68,105.88 PR1.1
  ART06 w0.508: v2(227.99,104.69) 227.92,104.76 226.4,104.76 225.43,105.72 220.94,105.72 218.98,103.76 214.57,103.76 213.75,102.95 209.49,102.95 208.05,101.51 200.85,101.51 199.15,103.21 v2(199.15,106.41)
  BOTTOM w0.203: v2(227.99,104.69) 227.93,104.69 227.88,104.64 227.88,104.39 227.27,103.79 U3.33
UGATE2: length 65.3
  TOP w0.508: PR43.1 v2(182.4,110.53)
  ART06 w0.508: v2(228.6,100.33) 228.55,100.28 228.55,99.49 227.24,98.17 227.24,97.02 226.27,96.05 191.46,96.05 189.03,98.48 183.14,98.48 182.26,99.37 182.26,110.39 v2(182.4,110.53)
  BOTTOM w0.203: U3.39 226.95,101.39 227.1,101.24
  BOTTOM w0.305: v2(228.6,100.33) 228.5,100.33 228.4,100.43 227.91,100.43 227.1,101.24
UGATE3: length 15.7
  TOP w0.508: v2(210.02,113.61) 209.89,113.73 209.89,114.55 210.44,115.1 PR65.1
  BOTTOM w0.254: 207.9,104.25 PU3.3
  BOTTOM w0.508: v2(210.02,113.61) 210.03,113.6 210.19,113.6 210.83,112.95 210.83,107.46 210.37,106.99 210.37,104.81 209.81,104.25 207.9,104.25
USB2_COMP: length 1.3
  TOP w0.203: v1(171.71,84.57) 171.81,84.47 U1.DN5
  BOTTOM w0.305: R612.2 171.89,84.75 v1(171.71,84.57)
USB2_DN0_CAM: length 3.2
  TOP w0.109: CN12.2 144.26,46.22 144.6,46.55 144.6,47.23 D33.N 144.32,48.53 R315.2
USB2_DN<1>: length 175
  TOP w0.076: U1.DN8 v1(171.56,82.2)
  ART06 w0.087: v1(171.56,82.2) 171.56,82.32 170.84,83.03 169.19,83.03 164.01,88.22 162.17,88.22 162.15,88.24 161.17,88.24 159.77,89.64 159.77,90.7 159.01,91.47 159.01,92.24 159.67,92.9 159.67,96.56 158.79,97.43 158.79,99.28 148.86,109.22 136.66,109.22 135.48,108.04 134.57,108.04 132.71,109.89 120.21,109.89 118.11,107.79 103.33,107.79 101.56,109.56 77.26,109.56 75.09,111.73 66.71,111.73 62.75,107.77 53.86,107.77 53.38,107.29 43.29,107.29 42.52,108.06 37.96,108.06 37.25,107.35 25.78,107.35 24.79,106.35 24.79,104.2 24.64,104.05 24.41,104.05 v1(24.16,104.29)
  BOTTOM w0.109: FIL1.4 23.22,104.29 v1(24.16,104.29)
USB2_DN<3>: length 78.4
  TOP w0.076: U1.DP13 171.12,80.01 v1(170.97,80.29)
  TOP w0.109: v1(134.41,90.51) 134.79,90.9 135.24,90.9 135.54,91.2 135.54,96.47 134.38,97.62 134.38,106.57 135.06,107.24 137.74,107.24 138.4,107.9 139.6,107.9 139.88,107.61 CN22.5
  ART03 w0.075: 163.31,90.88 163.33,90.88 163.35,90.9 167.31,90.9 169.18,92.77 170.68,92.77 172.43,91.02 172.43,90.5 172.86,90.08 172.86,86.34 172.5,85.98 172.5,83.64 172.64,83.5 172.64,82.91 172.21,82.48 172.21,81.13 171.88,80.81 171.34,80.81 171.2,80.66 171.2,80.54 v1(170.97,80.29)
  ART03 w0.087: v1(134.41,90.51) 134.63,90.73 135.7,90.73 136.72,89.71 138.08,89.71 138.81,88.97 142.02,88.97 142.96,89.91 154.04,89.91 155.5,91.38 158.99,91.38 159.48,90.88 163.31,90.88
USB2_DN<4>: length 165.1
  TOP w0.076: v1(172.86,81.29) 172.86,81.29 U1.DK10
  TOP w0.109: v1(46.44,86.96) 46.27,87.13 46.27,87.26 FIL4.1
  ART06 w0.087: v1(46.44,86.96) 46.03,87.38 46.03,87.71 55.72,97.41 55.72,104.74 60.91,104.74 66.9,110.74 74.76,110.74 76.77,108.72 100.18,108.72 102.02,106.88 118.47,106.88 120.62,109.03 132.37,109.03 134.36,107.04 135.74,107.04 137.06,108.37 148.53,108.37 157.04,99.85 157.04,94.55 157.97,93.62 157.97,91.29 158.94,90.32 158.94,89.21 160.75,87.4 162.52,87.4 163.64,86.22 163.64,84.8 167.29,81.14 170.17,81.14 170.64,81.61 173.01,81.61 173.13,81.49 173.13,81.4 173.03,81.29 v1(172.86,81.29)
USB2_DN<5>: length 72.7
  TOP w0.075: 162.55,89.75 162.62,89.83 162.62,89.87 163.55,90.81 167.65,90.81 168.34,90.12 169.57,90.12 170.47,89.22 170.47,87.67 171.05,87.09
  TOP w0.076: U1.DL5 172.19,84.75 172.17,85.04 172.1,85.17 172.02,85.38 172.02,85.58 172.07,85.68 172.07,85.85 171.97,86.16 171.05,87.09
  TOP w0.109: FIL13.3 144.58,50.66 144.58,50.91 144.15,51.34 144.15,53.08 143.45,53.78 143.45,58.89 144.59,60.03 146.15,60.03 146.25,60.13 146.25,60.22 v1(146.02,60.45) ; 162.55,89.75 162.09,89.3 162.09,88.76 161.28,87.94 159.34,87.94 157.33,85.94 157.33,84.24 156.76,83.67 156.13,83.67 155.58,83.12 150.24,83.12 149.99,82.88 v1(149.99,82.03)
  BOTTOM w0.109: v1(149.99,82.03) 149.79,82.24 149.79,83.03 149.48,83.33 148.44,83.33 147.7,82.59 147.7,80.52 145.96,78.78 145.96,77.48 146.3,77.14 146.3,71.91 147.1,71.11 147.1,63.05 146.21,62.15 146.21,60.63 v1(146.02,60.45)
USB2_DN<7>: length 197.6
  TOP w0.076: v1(172.84,79.43) 173.17,79.84 U1.DK13
  ART03 w0.075: 161.97,82.87 164,84.91 164,85.75 166.63,88.38 167.63,88.38 168.52,87.48 168.52,86.65 168.77,86.4 168.77,81.09 170.1,79.76 172.6,79.76 172.72,79.88 173.01,79.88 173.09,79.81 173.09,79.7 v1(172.84,79.43)
  ART03 w0.087: v1(38.55,68.78) 38.43,68.9 38.43,69.22 38.64,69.43 47.71,69.43 47.97,69.69 55.69,69.69 56.54,70.54 59.47,70.54 60.22,69.79 61.71,69.79 62.07,69.42 63.18,69.42 64.3,68.3 79.22,68.3 81.54,65.98 85.06,65.98 85.31,65.74 95.43,65.74 98.1,68.4 112.21,68.4 113.67,69.86 118.95,69.86 124.35,75.25 124.35,76.72 128,80.37 129.03,80.37 134.53,85.87 144.53,85.87 145.4,86.74 149.32,86.74 149.97,86.09 152.89,86.09 155.15,83.84 158.17,83.84 159.57,82.43 161.53,82.43 161.97,82.87
  BOTTOM w0.109: v1(38.55,68.78) 38.36,68.97 38.36,69.59 36.32,71.64 36.32,73.06 35.05,74.33 35.05,78 35.61,78.56 35.61,83.88 35.83,84.09 35.83,96.68 35.32,97.18 35.32,101.61 34.66,102.27 33.95,102.27 33.46,102.77 R477.1
USB2_DN<9>: length 188.8
  TOP w0.075: v1(171.18,89.51) 171.25,89.45 171.71,89.45 171.86,89.29 171.86,87.36 172.74,86.49 172.74,85.72 U1.DL2
  ART03 w0.075: v1(171.18,89.51) 169.93,89.51 169.57,89.16 164.85,89.16 163.9,88.21 162.1,88.21 162.09,88.22 161.97,88.22
  ART03 w0.087: 161.97,88.22 160.1,88.22 158.19,86.31 154.21,86.31 151.91,88.61 144.15,88.61 142.92,87.38 132.23,87.38 122.5,77.66 122.5,75.51 118.35,71.36 113.02,71.36 111.22,69.56 96.77,69.56 94.18,66.97 86.36,66.97 85.13,68.2 81.58,68.2 77.48,72.3 66.98,72.3 66.01,73.27 61.3,73.27 59.42,71.39 55.78,71.39 55.41,71.02 52.04,71.02 51.56,70.54 48.19,70.54 47.72,71.02 43.02,71.02 42.33,71.7 38.92,71.7 38.62,71.4 38.62,71 v1(38.5,70.89)
  BOTTOM w0.109: v1(38.5,70.89) 38.54,70.92 38.54,72.92 38.46,73 38.46,78.77 36.71,80.52 36.71,88.36 45.22,96.87 45.22,98.76 44.95,99.03 44.51,99.03 FIL14.1 44.01,98.54 R491.1
USB2_DP0_CAM: length 3.3
  TOP w0.109: CN12.3 145.26,46.2 144.82,46.65 144.82,47.1 D32.N 145.22,48.57 R489.2
USB2_DP<1>: length 174.9
  TOP w0.076: U1.DP8 v1(170.91,82.2)
  ART06 w0.087: v1(24.16,103.69) 24.34,103.87 24.71,103.87 24.97,104.13 24.97,106.28 25.86,107.17 37.32,107.17 38.04,107.88 42.45,107.88 43.22,107.11 53.46,107.11 53.94,107.59 62.83,107.59 66.79,111.55 75.01,111.55 77.18,109.38 101.48,109.38 103.25,107.61 118.18,107.61 120.29,109.71 132.63,109.71 134.49,107.85 135.56,107.85 136.74,109.04 148.78,109.04 158.61,99.21 158.61,97.36 159.48,96.48 159.48,92.98 158.82,92.32 158.82,91.39 159.59,90.63 159.59,89.56 161.09,88.06 163.94,88.06 169.12,82.87 170.78,82.87 171.13,82.52 171.13,82.42 v1(170.91,82.2)
  BOTTOM w0.109: FIL1.1 23.57,104.08 23.78,104.08 v1(24.16,103.69)
USB2_DP<3>: length 78.4
  TOP w0.076: U1.DN13 v1(171.59,80.32)
  TOP w0.109: CN22.3 138.31,108.11 137.65,107.46 134.97,107.46 134.16,106.66 134.16,97.53 135.32,96.38 135.32,91.29 135.15,91.12 v1(134.41,91.12)
  ART03 w0.075: v1(171.59,80.32) 171.35,80.53 171.35,80.6 171.4,80.65 171.95,80.65 172.36,81.07 172.36,82.42 172.79,82.85 172.79,83.56 172.65,83.7 172.65,85.91 173.01,86.28 173.01,90.14 172.58,90.57 172.58,91.08 170.75,92.92 169.12,92.92 167.25,91.05 163.35,91.05 163.33,91.07 163.31,91.07
  ART03 w0.087: v1(134.41,91.12) 134.61,90.92 135.78,90.92 136.8,89.89 138.15,89.89 138.89,89.16 141.95,89.16 142.89,90.1 153.97,90.1 155.43,91.56 159.07,91.56 159.56,91.07 163.31,91.07
USB2_DP<4>: length 165.5
  TOP w0.076: U1.DJ10 173.51,81.29 v1(173.51,81.29)
  TOP w0.109: v1(45.84,86.96) 46.05,87.17 46.05,87.26 FIL4.4
  ART06 w0.087: v1(45.84,86.96) 45.84,87.79 55.54,97.48 55.54,104.93 60.83,104.93 66.83,110.92 74.83,110.92 76.84,108.91 100.25,108.91 102.1,107.07 118.39,107.07 120.54,109.21 132.44,109.21 134.44,107.22 135.66,107.22 136.99,108.55 148.61,108.55 157.23,99.93 157.23,94.62 158.15,93.7 158.15,91.36 159.12,90.39 159.12,89.29 160.82,87.58 162.17,87.58 162.19,87.56 162.59,87.56 163.8,86.28 163.8,84.86 167.36,81.3 170.1,81.3 170.57,81.78 173.08,81.78 173.3,81.56 173.3,81.46 173.47,81.29 v1(173.51,81.29)
USB2_DP<5>: length 72.8
  TOP w0.075: 162.45,89.92 163.49,90.96 167.72,90.96 168.4,90.27 169.63,90.27 170.62,89.28 170.62,87.77 171.22,87.16
  TOP w0.076: 171.22,87.16 172.13,86.25 172.25,85.87 172.25,85.64 172.2,85.54 172.2,85.41 172.27,85.25 172.39,85.14 172.64,85.14 172.74,85.04 172.74,84.86 172.69,84.81 U1.DL3
  TOP w0.109: R489.1 144.8,50.75 144.8,51 144.36,51.43 144.36,53.18 143.67,53.87 143.67,58.8 144.68,59.81 146.24,59.81 146.47,60.04 146.47,60.37 146.54,60.45 v1(146.62,60.45) ; 162.45,89.92 162.41,89.92 161.87,89.39 161.87,88.85 161.19,88.16 159.25,88.16 157.12,86.03 157.12,84.33 156.67,83.89 156.04,83.89 155.49,83.34 150.15,83.34 149.77,82.97 149.77,82.41 v1(149.39,82.03)
  BOTTOM w0.109: v1(146.62,60.45) 146.42,60.65 146.42,62.06 147.32,62.96 147.32,71.2 146.52,72 146.52,77.23 146.18,77.57 146.18,78.69 147.92,80.43 147.92,82.5 148.53,83.11 149.39,83.11 149.57,82.94 149.57,82.21 v1(149.39,82.03)
USB2_DP<7>: length 197.8
  TOP w0.076: U1.DJ13 v1(173.51,79.46)
  ART03 w0.075: v1(173.51,79.46) 173.24,79.71 173.24,79.81 173.24,79.87 173.07,80.03 172.66,80.03 172.53,79.91 170.16,79.91 168.92,81.15 168.92,86.47 168.67,86.71 168.67,87.55 167.69,88.53 166.57,88.53 163.85,85.81 163.85,84.97 162.08,83.19 162.03,83.19 161.97,83.13
  ART03 w0.087: v1(37.95,68.78) 38.25,69.08 38.25,69.3 38.56,69.62 47.63,69.62 47.9,69.88 55.61,69.88 56.46,70.73 59.54,70.73 60.3,69.97 61.79,69.97 62.15,69.61 63.25,69.61 64.37,68.49 79.29,68.49 81.61,66.17 85.14,66.17 85.38,65.92 95.36,65.92 98.02,68.59 112.14,68.59 113.59,70.04 118.88,70.04 124.17,75.33 124.17,76.8 127.92,80.55 128.95,80.55 134.45,86.05 144.45,86.05 145.33,86.92 149.4,86.92 150.04,86.28 152.97,86.28 155.22,84.02 158.25,84.02 159.65,82.62 161.46,82.62 161.97,83.13
  BOTTOM w0.109: R479.1 33.45,101.49 34.01,102.05 34.57,102.05 35.1,101.52 35.1,97.09 35.61,96.58 35.61,84.18 35.39,83.97 35.39,78.65 34.83,78.09 34.83,74.24 36.1,72.97 36.1,71.55 38.14,69.5 38.14,68.97 v1(37.95,68.78)
USB2_DP<9>: length 188.8
  TOP w0.075: U1.DL1 172.48,86.53 171.71,87.3 171.71,87.56 171.64,87.63 171.48,87.63 171.39,87.72 171.39,87.86 171.46,87.93 171.64,87.93 171.71,88.01 171.71,89.23 171.65,89.3 171.57,89.3 v1(171.18,88.91)
  ART03 w0.075: v1(171.18,88.91) 170.73,89.36 169.99,89.36 169.64,89.01 164.91,89.01 163.96,88.06 162,88.06 161.98,88.04 161.97,88.04
  ART03 w0.087: 161.97,88.04 160.18,88.04 158.27,86.13 154.13,86.13 151.83,88.43 144.22,88.43 143,87.2 132.3,87.2 122.68,77.58 122.68,75.43 118.43,71.18 113.09,71.18 111.29,69.38 96.84,69.38 94.26,66.79 86.29,66.79 85.06,68.02 81.51,68.02 77.41,72.12 66.9,72.12 65.94,73.08 61.37,73.08 59.5,71.21 55.86,71.21 55.49,70.83 52.12,70.83 51.64,70.36 48.12,70.36 47.64,70.83 42.94,70.83 42.26,71.52 39,71.52 38.8,71.32 38.8,71.19 v1(39.1,70.89)
  BOTTOM w0.109: R488.1 44.02,99.74 FIL14.4 44.51,99.25 45.04,99.25 45.44,98.86 45.44,96.78 36.93,88.27 36.93,80.61 38.68,78.86 38.68,73.09 38.76,73.01 38.76,71.23 v1(39.1,70.89)

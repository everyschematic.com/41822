# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A10: length 93.7
  TOP w0.135: v1(193.56,16.51) 193.62,16.45 195.12,16.45 195.26,16.58 195.26,16.8 195.39,16.94 195.66,16.94 195.8,16.8 195.8,16.58 195.93,16.45 196.24,16.45 196.5,16.71 196.5,17.14 195.34,18.29 195.34,18.84 195.52,19.03 196.27,19.03 196.52,18.77 196.52,18.1 196.66,17.97 196.93,17.97 197.06,18.1 197.06,18.85 197.47,19.26 CN19.146 ; U1.P39 210.36,67.33 v1(210.76,67.1)
  ART03 w0.102: 211,65.45 211,65.54 211.13,65.67 211.13,65.68 211.13,66.96 210.99,67.1 v1(210.76,67.1)
  ART03 w0.108: v1(193.56,16.51) 193.59,16.51 193.71,16.63 193.71,19.66 193.53,19.85 191.84,19.85 191.73,19.95 191.73,20.17 191.84,20.28 193.56,20.28 193.66,20.39 193.66,20.6 193.56,20.71 191.41,20.71 191.3,20.6 191.3,19.95 191.19,19.85 190.77,19.85 190.64,19.98 190.64,21.08 190.8,21.24 193.43,21.24 193.57,21.38 193.57,21.66 193.01,22.22 193.01,25.19 194.04,26.22 194.04,26.99 194.15,27.09 195.44,27.09 195.55,27.2 195.55,27.42 195.44,27.53 194.15,27.53 194.04,27.63 194.04,27.85 194.15,27.96 195.44,27.96 195.55,28.07 195.55,28.28 195.44,28.39 194.15,28.39 194.04,28.5 194.04,28.92 194.26,29.14 194.41,29.14 194.64,28.91 194.79,28.91 194.94,29.06 194.94,29.22 194.72,29.44 194.72,29.59 194.87,29.75 195.02,29.75 195.25,29.52 195.4,29.52 195.55,29.68 195.55,29.83 195.33,30.05 195.33,30.2 195.63,30.5 195.63,35.67 199.3,39.34 205.06,39.34 212.24,46.52 212.24,51.87 212.64,52.27 212.64,55.55 211.76,56.42 211.76,62.53 211,63.3 211,65.45
M_B_A11: length 94.8
  TOP w0.076: 216.55,55.26 216.55,57.21 216.18,57.58 213.73,57.58 212.42,58.89 210.88,60.43 210.88,60.55 210.88,60.55 210.88,60.61 210.88,60.89 210.52,61.25 210.52,61.27 210.31,61.48 210.31,61.77 210.43,62.15 210.43,62.51 210.39,62.6 210.37,62.62 210.37,62.78 210.41,62.88 210.45,62.96 210.45,63.25 210.54,63.35 210.54,63.72 U1.N46
  TOP w0.135: CN19.120 188.97,18.16 v1(189,18.14) ; v1(217.81,53.33) 217.92,53.44 218.3,53.44 219.01,52.73 219.01,51.48 218.77,51.24 218.45,51.24 216.59,53.1 216.59,55.22 216.55,55.26
  ART03 w0.108: v1(189,18.14) 189.17,17.97 190.11,17.97 190.64,18.5 190.81,18.5 191.04,18.27 191.04,18.04 190.66,17.66 190.66,16.93 190.12,16.39 189.28,16.39 189.13,16.24 189.13,12.44 190.01,11.56 200.31,11.56 200.69,11.94 200.69,17.93 200.27,18.35 200.27,19.95 203.76,23.44 203.76,27.46 204.45,28.14 204.45,31.6 205.36,32.52 206.07,32.52 217.92,44.37 217.92,53.22 v1(217.81,53.33)
M_B_A12: length 95.2
  TOP w0.076: v1(215.83,56.45) 215.05,57.24 213.99,57.24 213.99,57.24 213.61,57.24 212.09,58.76 212.09,58.76 210.55,60.29 210.55,60.68 210.55,60.68 210.55,60.75 210.19,61.12 210.19,61.14 209.94,61.38 209.94,62.22 209.92,62.24 209.92,62.5 209.94,62.52 209.94,62.55 210.05,62.65 210.19,63 U1.R48
  TOP w0.135: v1(189.77,14.45) 189.55,14.67 188.92,14.67 188.72,14.48 CN19.119
  ART03 w0.108: v1(215.83,56.45) 215.47,56.82 215.47,57.34 215.67,57.55 217.23,57.55 217.35,57.43 217.35,52.98 217.54,52.78 217.54,44.54 205.89,32.89 205.33,32.89 204.12,31.68 204.12,28.64 203.07,27.59 203.07,27.26 203.18,27.16 203.38,27.16 203.49,27.05 203.49,26.83 203.38,26.72 203.18,26.72 203.07,26.62 203.07,26.4 203.18,26.29 203.38,26.29 203.49,26.18 203.49,23.65 200.85,21.02 200.71,21.02 200.56,21.17 200.56,21.33 203.04,23.82 203.04,23.98 202.89,24.14 202.75,24.14 199.99,21.38 199.99,18.24 200.43,17.81 200.43,12.14 200.1,11.82 199.06,11.82 198.95,11.93 198.95,12.15 199.05,12.25 199.84,12.25 199.94,12.34 199.94,12.56 199.81,12.68 198.67,12.68 198.43,12.45 198.43,11.93 198.33,11.82 191.14,11.82 189.42,13.55 189.42,14.36 189.5,14.45 v1(189.77,14.45)
M_B_A13: length 97
  TOP w0.135: U1.Y41 207.78,66.59 v1(208.02,66.46) ; CN19.158 200.47,18.36 200.87,17.97 201.17,17.97 202.37,16.77 202.4,16.77 202.41,16.76 202.68,16.76 202.85,16.59 202.85,16.18 202.71,16.04 202.27,16.04 202.13,15.91 202.13,15.64 202.27,15.5 202.71,15.5 202.85,15.37 202.85,15.05 202.66,14.86 198.2,14.86 197.67,15.39 192.37,15.39 191.85,15.92 187.66,15.92 187.4,15.65 187.21,15.65 187.02,15.85 187.02,16.04 187.43,16.45 187.43,16.64 187.25,16.82 186.01,16.82 185.88,16.95 185.88,17.2 185.74,17.33 185.47,17.33 185.34,17.2 185.34,16.95 185.2,16.82 184.97,16.82 184.38,16.23 v1(184.21,16.23)
  ART03 w0.108: v1(184.21,16.23) 183.43,17.01 183.43,19.65 183.06,20.01 183.06,23.6 184.94,25.48 184.94,31.35 184.97,31.38 184.97,31.4 185.1,31.53 185.1,31.55 187.2,33.65 187.22,33.65 187.48,33.65 187.48,33.65 188,33.65 197.42,43.07 203.46,43.07 208.49,48.09 208.49,50.93 209.49,51.94 209.49,58.96 207.71,60.74 207.71,64.74 207.65,64.81 207.65,66.09 v1(208.02,66.46)
M_B_ACT_N: length 93
  TOP w0.076: U1.M48 211.48,62.89 211.33,62.75 211.22,62.44 211.22,62.17 211.44,61.95 211.44,60.58 212.91,59.1 213.85,58.17 216.74,58.17 v1(217.77,57.13)
  TOP w0.135: v1(187.33,17.72) 187.33,18.61 187.47,18.75 CN19.114
  ART03 w0.108: v1(187.33,17.72) 186.71,17.1 186.71,14.6 186.33,14.22 186.33,13.53 186.73,13.12 186.73,11.32 188.33,9.72 201.37,9.72 201.37,9.72 201.58,9.72 201.61,9.72 203.21,11.33 203.21,19.77 208.29,24.85 208.29,28.34 208.88,28.92 208.88,32.26 220.07,43.45 220.07,56.33 219.02,57.38 218.02,57.38 v1(217.77,57.13)
M_B_BG0: length 94.2
  TOP w0.076: v1(217.8,55.89) 217.43,55.53 217.24,55.53 217.02,55.74 217.02,56.17 217.1,56.25 217.32,56.25 217.4,56.33 217.4,56.48 217.32,56.55 217.1,56.55 217.02,56.63 217.02,56.78 217.1,56.86 217.32,56.86 217.4,56.94 217.4,57.09 217.32,57.16 217.1,57.16 217.02,57.24 217.02,57.63 216.66,57.99 213.79,57.99 212.75,59.03 212.75,59.03 211.27,60.52 211.27,61.86 211.04,62.08 211.04,62.47 211.13,62.7 211.13,64.2 210.95,64.38 210.65,64.38 210.59,64.44 210.29,64.44 U1.R45
  TOP w0.135: CN19.115 187.72,13.91 187.9,14.08 188.05,14.08 v1(188.2,13.93)
  ART03 w0.108: v1(217.8,55.89) 217.93,56.03 218.27,56.03 218.41,55.88 218.41,54.1 218.87,53.64 218.87,43.86 206.55,31.53 206.55,31.33 206.44,31.22 206.03,31.22 205.92,31.11 205.92,30.9 206.03,30.79 206.44,30.79 206.55,30.68 206.55,30.46 206.44,30.36 206.03,30.36 205.92,30.25 205.92,30.03 206.03,29.92 206.44,29.92 206.55,29.82 206.55,29.58 206.43,29.46 206.31,29.46 206.22,29.36 206.22,28.77 206.32,28.67 206.97,28.67 207.08,28.56 207.08,28.34 206.97,28.23 206.32,28.23 206.22,28.13 206.22,27.76 205.77,27.31 205.77,26.24 205.66,26.13 205.24,26.13 205.13,26.02 205.13,25.81 205.24,25.7 205.66,25.7 205.77,25.59 205.77,25.37 205.66,25.27 205.24,25.27 205.13,25.16 205.13,24.94 205.24,24.84 205.66,24.84 205.77,24.73 205.77,24.18 205.64,24.05 205.33,24.05 204.93,24.46 204.77,24.46 204.62,24.3 204.62,24.15 205.1,23.67 205.1,23.52 201.58,19.99 201.58,18.1 202.03,17.65 202.03,13.6 201.48,13.06 201.48,11.16 201.08,10.77 189.19,10.77 188.31,11.64 188.31,13.82 v1(188.2,13.93)
M_B_BG1: length 93.8
  TOP w0.076: U1.N47 210.61,63.14 210.61,62.91 210.55,62.75 210.55,62.72 210.55,62.72 210.55,62.67 210.63,62.46 210.63,62.06 210.48,61.64 210.48,61.55 210.68,61.34 210.68,61.32 211.05,60.96 211.05,60.55 211.05,60.5 212.58,58.96 212.58,58.96 213.8,57.75 216.24,57.75 216.78,57.21 216.78,55.6 216.87,55.52
  TOP w0.135: v1(217.81,55.27) 217.56,55.27 217.42,55.13 217.42,53.53 217.26,53.38 217.04,53.38 216.87,53.55 216.87,55.52 ; v1(188.21,14.56) 187.43,14.56 187.22,14.36 CN19.113
  ART03 w0.108: v1(217.81,55.27) 218.21,54.86 218.21,53.94 218.56,53.59 218.56,43.99 206.42,31.85 205.58,31.85 205.08,31.35 205.08,29.43 205.19,29.33 205.84,29.33 205.95,29.22 205.95,29 205.84,28.89 205.19,28.89 205.08,28.79 205.08,28.57 205.19,28.46 205.84,28.46 205.95,28.35 205.95,28.14 205.84,28.03 205.19,28.03 204.99,27.84 204.99,27.68 205.31,27.37 205.31,27.22 205.16,27.06 205,27.06 204.69,27.38 204.54,27.38 204.31,27.16 204.31,23.17 201.31,20.16 201.31,18.09 201.22,18 201.22,17.52 201.33,17.41 201.6,17.41 201.7,17.3 201.7,17.08 201.6,16.98 201.33,16.98 201.22,16.87 201.22,16.65 201.33,16.54 201.6,16.54 201.7,16.44 201.7,16.22 201.6,16.11 201.33,16.11 201.22,16 201.22,15.79 201.33,15.68 201.6,15.68 201.7,15.57 201.7,15.36 201.6,15.25 201.33,15.25 201.22,15.14 201.22,11.49 200.76,11.03 189.46,11.03 188.58,11.9 188.58,14.41 188.43,14.56 v1(188.21,14.56)
M_B_BS0: length 93.3
  TOP w0.135: v1(209.85,67.73) 209.66,67.85 U1.T38 ; CN19.150 198.47,19.56 198.61,19.43 198.61,18.87 198.47,18.74 198.24,18.74 198.1,18.6 198.1,18.33 198.24,18.2 198.47,18.2 198.61,18.06 198.61,17.85 198.37,17.6 197.04,17.6 196.85,17.41 196.85,16.94 197.05,16.74 198.73,16.74 198.94,16.52 198.94,16.23 198.8,16.09 192.99,16.09 v1(192.7,16.37)
  ART03 w0.108: v1(209.85,67.73) 210.26,67.73 210.38,67.61 210.38,65.6 210.54,65.45 210.54,63.05 211.39,62.19 211.39,56.26 212.08,55.57 212.08,52.34 211.62,51.87 211.62,46.78 204.8,39.96 199.04,39.96 195.01,35.93 195.01,30.86 194.56,30.41 194.4,30.41 194.2,30.61 194.04,30.61 193.89,30.46 193.89,30.31 194.1,30.1 194.1,29.95 193.95,29.8 193.79,29.8 193.58,30 193.43,30 193.28,29.85 193.28,29.7 193.4,29.58 193.4,29.38 193.29,29.27 193.2,29.27 193.09,29.16 193.09,28.95 193.2,28.84 193.29,28.84 193.4,28.73 193.4,28.52 193.29,28.41 193.2,28.41 193.09,28.3 193.09,28.08 193.2,27.98 193.29,27.98 193.4,27.87 193.4,27.65 193.29,27.55 193.2,27.55 193.09,27.44 193.09,27.22 193.2,27.11 193.29,27.11 193.4,27.01 193.4,26.64 192.96,26.2 191.99,26.2 191.45,25.66 191.45,23.79 191.98,23.26 191.98,22.5 191.5,22.02 187.6,22.02 187.08,21.5 187.08,19.8 187.7,19.18 191.89,19.18 192.25,18.82 192.25,17.9 192.36,17.79 192.61,17.79 192.76,17.94 192.91,17.94 193.06,17.78 193.06,17.63 192.95,17.51 192.87,17.43 192.87,17.28 192.87,16.53 v1(192.7,16.37)
M_B_BS1: length 96.1
  TOP w0.135: v1(193.44,14.9) 193.58,15.04 195.9,15.04 196.04,14.91 196.04,14.52 196.17,14.39 196.44,14.39 196.58,14.52 196.58,14.91 196.71,15.04 197.06,15.04 197.25,14.85 197.25,14.1 197.09,13.94 196.73,13.94 196.43,13.64 196.43,11.13 196.57,11 196.86,11 197,10.86 197,10.59 196.86,10.46 196.57,10.46 196.43,10.32 196.43,10.05 196.57,9.92 196.99,9.92 197.12,9.78 197.12,9.51 196.99,9.38 196.57,9.38 196.43,9.24 196.43,8.79 196.61,8.62 197.09,8.62 197.86,9.39 197.86,10.77 197.22,11.4 CN19.145 ; U1.T42 v1(209.85,65.83)
  ART03 w0.108: v1(209.85,65.83) 209.85,65.73 210.3,65.28 210.3,61.76 211.21,60.85 211.21,56.18 211.74,55.65 211.74,52.32 211.4,51.99 211.4,50.59 211.31,50.49 211.31,46.91 204.67,40.27 198.91,40.27 194.7,36.05 194.7,31.76 192.95,30.02 192.95,29.74 192.71,29.5 192.71,26.89 192.38,26.56 191.84,26.56 191.13,25.85 191.13,23.54 191.64,23.04 191.64,22.64 191.34,22.34 187.48,22.34 186.77,21.63 186.77,19.67 187.58,18.87 191.68,18.87 191.9,18.65 191.9,16.93 191.64,16.67 191.64,16.13 191.98,15.79 191.98,15.25 192.09,15.14 192.31,15.14 192.41,15.25 192.41,15.79 192.52,15.89 192.74,15.89 192.85,15.79 192.85,15.55 192.95,15.44 193.17,15.44 193.28,15.55 193.28,15.79 193.39,15.89 193.64,15.89 193.73,15.8 193.73,15.2 v1(193.44,14.9)
M_B_CAS_N: length 96.1
  TOP w0.135: v1(184.25,16.84) 184.25,17.11 184.85,17.7 185.44,17.7 185.57,17.84 185.57,18.28 185.72,18.43 185.99,18.43 186.11,18.3 186.11,17.84 186.25,17.7 186.62,17.7 187.06,17.26 187.29,17.26 188.27,16.28 192.07,16.28 192.6,15.75 197.88,15.75 198.42,15.2 198.91,15.2 199.05,15.34 199.05,15.66 199.18,15.79 199.45,15.79 199.59,15.66 199.59,15.34 199.72,15.2 199.99,15.2 200.13,15.34 200.13,15.66 200.26,15.79 200.53,15.79 200.67,15.66 200.67,15.34 200.8,15.2 201.41,15.2 201.7,15.49 201.7,16.59 199.97,18.31 CN19.156 ; U1.Y42 v1(208.02,65.83)
  ART03 w0.108: v1(208.02,65.83) 207.92,65.73 207.92,60.85 209.68,59.09 209.68,51.75 208.8,50.87 208.8,48.73 208.8,47.96 203.59,42.76 197.55,42.76 191.37,36.58 191.37,35.18 191.03,34.84 190.87,34.84 190.34,35.37 190.19,35.37 190.04,35.22 190.04,35.06 190.57,34.53 190.57,34.38 190.18,33.99 189.23,33.99 188.57,33.34 187.35,33.34 185.28,31.27 185.28,31.25 185.25,31.22 185.25,25.36 185.2,25.3 185.2,25.3 183.38,23.48 183.38,20.68 184.43,19.63 184.43,17.03 v1(184.25,16.84)
M_B_CB0: length 3.7
  TOP w0.135: v1(182.98,18.26) 182.79,18.26 182.44,18.61 182.44,18.62 181.97,19.08 CN19.92
  BOTTOM w0.305: v1(182.98,18.26) 182.81,18.26 182.45,17.9 R291.2
M_B_CB1: length 2.7
  TOP w0.135: v1(181.22,14.43) 181.72,13.93 CN19.91
  BOTTOM w0.305: R293.2 181.56,14.43 v1(181.22,14.43)
M_B_CB2: length 2.1
  TOP w0.135: CN19.101 184.22,13.79 184.19,13.82 v1(184.19,13.84)
  BOTTOM w0.109: v1(184.19,13.84) 184.32,13.71 R294.2
M_B_CB3: length 3.7
  TOP w0.135: CN19.105 185.22,14.13 184.34,15.01 v1(184.19,15.01)
  BOTTOM w0.109: R295.2 184.21,15.03 v1(184.19,15.01)
M_B_CB4: length 2.8
  TOP w0.135: v1(181.48,18.84) 181.38,18.84 180.97,19.25 CN19.88
  BOTTOM w0.109: R296.2 181.29,19.04 v1(181.48,18.84)
M_B_CB5: length 2.7
  TOP w0.135: v1(180.22,14.43) 180.72,13.93 CN19.87
  BOTTOM w0.109: R297.2 180.14,14.34 v1(180.22,14.43)
M_B_CB6: length 1.9
  TOP w0.135: CN19.100 183.98,20.71 v1(183.98,19.43)
  BOTTOM w0.109: R298.2 183.65,19.76 v1(183.98,19.43)
M_B_CB7: length 3.4
  TOP w0.135: CN19.104 184.97,19.25 v1(183.98,18.26)
  BOTTOM w0.109: R299.2 183.99,18.26 v1(183.98,18.26)
M_B_CKE<0>: length 97.3
  TOP w0.076: v1(215.85,54.61) 215.31,54.61 215.16,54.76 215.16,54.99 215.24,55.07 215.39,55.07 215.47,55.14 215.47,55.3 215.39,55.37 215.24,55.37 215.16,55.45 215.16,55.6 215.24,55.68 215.39,55.68 215.47,55.75 215.47,55.91 215.39,55.98 215.24,55.98 215.16,56.06 215.16,56.35 214.74,56.78 212.53,56.78 210.16,59.15 210.16,59.57 209.15,60.58 209.15,61.14 209.37,61.36 209.37,62.4 209.33,62.55 209.22,63.01 209.22,63.8 U1.U45
  TOP w0.135: CN19.109 186.22,14.12 186.53,14.43 186.53,14.86 185.92,15.47 185.72,15.47 185.52,15.28 185.52,15.1 185.89,14.74 185.89,14.55 185.7,14.36 185.51,14.36 184.66,15.2 184.66,15.73 185.31,16.37 185.94,16.37 187.33,14.99 189.39,14.99 189.49,15.09 v1(189.77,15.09)
  ART03 w0.108: v1(215.85,54.61) 216.23,54.61 216.56,54.28 216.56,52.92 216.91,52.57 216.91,44.79 213.43,41.31 212.99,41.31 212.85,41.45 212.69,41.45 212.54,41.3 212.54,41.15 212.83,40.86 212.83,40.71 212.67,40.55 212.52,40.55 212.23,40.84 212.08,40.84 211.93,40.69 211.93,40.54 212.22,40.25 212.22,40.1 212.06,39.94 211.91,39.94 211.62,40.23 211.47,40.23 211.32,40.08 211.32,39.92 211.6,39.64 211.6,39.48 211.45,39.33 211.3,39.33 211.01,39.62 210.86,39.62 210.71,39.47 210.71,39.31 210.99,39.03 210.99,38.87 210.76,38.64 210.61,38.64 210.33,38.92 210.18,38.92 210.03,38.77 210.03,38.62 210.31,38.34 210.31,38.19 210.15,38.03 210,38.03 209.72,38.31 209.57,38.31 209.42,38.16 209.42,38.01 209.69,37.73 209.69,37.57 209.54,37.42 209.39,37.42 209.11,37.7 208.96,37.7 208.8,37.55 208.8,37.39 209.08,37.12 209.08,36.96 208.93,36.81 208.78,36.81 208.5,37.09 208.35,37.09 208.19,36.94 208.19,36.78 208.47,36.5 208.47,36.35 208.32,36.2 208.17,36.2 207.89,36.48 207.73,36.48 207.58,36.33 207.58,36.17 207.75,36.01 207.75,35.63 205.78,33.66 205.17,33.66 203.37,31.86 203.37,28.94 202.4,27.97 202.4,25.35 199.86,22.81 199.86,22.22 198.85,21.2 198.85,16.7 198.49,16.34 198.49,13.43 197.4,12.34 191.71,12.34 190.25,13.8 190.25,14.81 189.97,15.09 v1(189.77,15.09)
M_B_CKE<1>: length 97
  TOP w0.135: U1.P43 v1(209.87,65.18) ; v1(190.49,22.73) 190.68,22.73 191.14,22.27 191.14,22.09 190.98,21.92 190.27,21.92 190.19,22 190.19,22.17 190.05,22.31 189.78,22.31 189.65,22.17 189.65,22.04 189.52,21.91 189.28,21.91 189.13,22.07 189.13,22.69 188.98,22.84 188.71,22.84 188.59,22.71 188.59,22.07 188.47,21.95 187.75,21.95 187.65,22.04 187.65,22.46 187.5,22.61 187.23,22.61 187.11,22.49 187.11,22.11 186.96,21.95 186.61,21.95 186.47,21.82 CN19.110
  ART03 w0.108: v1(190.49,22.73) 190.49,23.05 190.25,23.29 188.68,23.29 188.57,23.4 188.57,23.61 188.68,23.72 190.71,23.72 190.82,23.83 190.82,24.04 190.71,24.15 188.55,24.15 188.44,24.26 188.44,24.48 188.55,24.58 190.71,24.58 190.82,24.69 190.82,24.96 190.71,25.06 190.29,25.06 190.18,25.17 190.18,25.6 190.43,25.85 190.67,25.85 191.62,26.8 191.62,27.83 191.16,28.29 189.96,28.29 189.85,28.18 189.85,28.02 190.01,27.87 190.01,27.73 189.86,27.58 189.68,27.58 189.5,27.76 189.35,27.76 189.24,27.64 189.24,27.1 189.32,27.02 190.51,27.02 190.64,26.89 190.64,26.68 190.55,26.59 189.32,26.59 189.21,26.48 189.21,26.26 189.32,26.16 189.63,26.16 189.74,26.05 189.74,25.83 189.63,25.72 189.32,25.72 189.21,25.62 189.21,25.21 189.09,25.09 187.8,25.09 187.62,25.27 187.62,25.46 187.73,25.57 188.26,25.57 188.37,25.68 188.37,25.89 188.26,26 187.73,26 187.62,26.11 187.62,26.32 187.73,26.43 188.26,26.43 188.37,26.54 188.37,26.76 188.26,26.86 188.15,26.86 188.02,26.99 188.02,27.25 189.53,28.76 190.92,28.76 191.19,29.03 191.19,30.35 191.4,30.56 191.92,30.56 192.11,30.37 192.11,29.85 192.22,29.74 192.43,29.74 192.54,29.85 192.54,31.24 192.71,31.41 193.09,31.41 193.37,31.14 193.59,31.14 193.78,31.34 193.78,31.49 193.38,31.9 193.38,32.05 193.53,32.2 193.68,32.2 194.09,31.8 194.24,31.8 194.38,31.94 194.38,36.18 198.78,40.58 204.54,40.58 211,47.03 211,50.48 211.22,50.71 211.22,52.06 211.45,52.3 211.45,55.68 211.03,56.1 211.03,60.77 210,61.79 210,65.04 v1(209.87,65.18)
M_B_CLK_DDR_DN*<0>: length 99.5
  TOP w0.076: 208.85,50.95 208.85,52.93 209.64,53.72 209.64,57.94 208.85,58.72 208.85,59.24 207.94,60.15 207.94,60.17 207.8,60.31 207.8,60.81 207.46,61.15 207.46,61.16 207.44,61.18 207.44,62.53 207.62,62.71 207.62,62.98 U1.Y48
  TOP w0.109: CN19.139 193.72,13.5 193.63,13.6 193.64,13.6 193.64,14.17 193.33,14.48 193.14,14.48 v1(192.92,14.7) ; v1(214.23,52.34) 214.23,52.31 213.82,51.9 213.53,51.9 213.27,51.63 213.27,51.35 212.99,51.07 212.99,47.54 211.98,46.53 209.59,46.53 208.86,47.27 208.86,50.94 208.85,50.95
  ART03 w0.087: v1(192.92,14.7) 193.22,14.4 193.22,14.32 193.3,14.24 194.5,14.24 194.83,14.57 194.83,14.69 194.47,15.05 194.47,15.33 194.7,15.56 194.97,15.56 195.34,15.19 195.46,15.19 195.85,15.59 195.85,15.98 195.77,16.06 194.74,16.06 194.55,16.26 194.55,16.58 194.74,16.77 195.77,16.77 195.85,16.86 195.85,21.06 195.36,21.55 195.36,24.09 196.95,25.67 196.95,29.82 197.62,30.49 197.62,30.61 197.09,31.14 197.09,31.42 197.32,31.65 197.59,31.65 198.12,31.12 198.25,31.12 198.37,31.24 198.37,31.36 197.25,32.48 197.25,32.75 197.48,32.98 197.76,32.98 198.87,31.87 199,31.87 199.12,31.99 199.12,32.11 198.59,32.64 198.59,32.92 198.82,33.15 199.1,33.15 199.62,32.62 199.75,32.62 200.08,32.95 200.08,33.18 198.48,34.77 198.48,35.14 198.83,35.48 199.21,35.48 199.6,35.09 200,35.09 201.92,37.01 201.92,37.13 201.79,37.26 201.67,37.26 200.04,35.63 199.76,35.63 199.53,35.86 199.53,36.13 201.41,38 205.61,38 213.58,45.97 213.58,51.59 214.23,52.25 v1(214.23,52.34)
M_B_CLK_DDR_DN*<1>: length 93.4
  TOP w0.076: v1(211.68,65.18) U1.M43
  TOP w0.109: CN19.140 193.97,19.73 193.8,19.55 193.8,17.76 193.9,17.66 194.27,17.66 v1(194.47,17.85)
  ART03 w0.087: v1(211.68,65.18) 211.69,65.18 212.01,65.5 212.14,65.5 212.19,65.45 212.19,65.04 211.5,64.35 211.5,63.73 212.32,62.91 212.32,61.99 213.35,60.95 213.35,60.83 212.27,59.74 212.27,59.48 212.48,59.26 212.74,59.26 213.83,60.35 213.95,60.35 215.67,58.64 217.15,58.64 217.29,58.49 217.29,58.19 217.12,58.01 215.51,58.01 215.22,58.3 214.53,58.3 213.76,59.07 213.5,59.07 213.28,58.85 213.28,58.59 214.05,57.82 214.05,57.7 213.93,57.58 213.81,57.58 213.04,58.35 212.78,58.35 212.56,58.13 212.56,57.87 213.33,57.1 213.33,56.98 212.75,56.39 212.75,56.13 212.96,55.91 213.22,55.91 214.73,57.43 214.86,57.43 214.98,57.3 214.98,57.18 213.47,55.68 213.47,53.55 213.45,53.53 213.45,52.33 212.96,51.84 212.96,46.23 205.36,38.62 201.09,38.62 197.34,34.87 197.21,34.87 197.09,34.99 197.09,35.11 199.48,37.5 199.48,37.77 199.26,38 198.97,38 196.34,35.37 196.34,25.89 194.63,24.18 194.63,21.31 195.18,20.76 195.18,19.43 195.09,19.35 194.95,19.35 194.86,19.26 194.86,19.09 194.95,19 195.09,19 195.18,18.91 195.18,18.74 195.09,18.65 194.95,18.65 194.86,18.57 194.86,18.39 194.95,18.31 195.09,18.31 195.18,18.22 195.18,18.11 194.76,17.69 194.64,17.69 v1(194.47,17.85)
M_B_CLK_DDR_DP<0>: length 99.4
  TOP w0.076: 208.64,51.01 208.69,51.07 208.69,52.99 209.49,53.79 209.49,57.87 208.67,58.69 208.67,59.17 207.76,60.08 207.76,60.09 207.62,60.23 207.62,60.74 207.28,61.08 207.28,61.08 207.26,61.1 207.26,62.6 207.37,62.72 207.37,63.39 U1.Y47
  TOP w0.109: v1(192.92,14.1) 193.08,14.26 193.24,14.26 193.42,14.08 193.42,13.69 193.22,13.5 CN19.137 ; v1(214.23,51.71) 213.93,51.71 213.21,50.98 213.21,47.45 212.07,46.32 209.5,46.32 208.64,47.18 208.64,51.01
  ART03 w0.087: v1(214.23,51.71) 214.19,51.75 214.02,51.75 213.76,51.48 213.76,45.89 205.69,37.82 201.48,37.82 199.72,36.06 199.72,35.93 199.84,35.81 199.96,35.81 201.59,37.44 201.87,37.44 202.1,37.21 202.1,36.94 200.07,34.91 199.52,34.91 199.13,35.3 198.91,35.3 198.67,35.06 198.67,34.85 200.26,33.25 200.26,32.88 199.82,32.44 199.55,32.44 199.02,32.96 198.9,32.96 198.77,32.84 198.77,32.72 199.3,32.19 199.3,31.92 199.07,31.69 198.8,31.69 197.69,32.79 197.55,32.79 197.44,32.68 197.44,32.55 198.55,31.44 198.55,31.17 198.32,30.94 198.05,30.94 197.52,31.46 197.4,31.46 197.27,31.34 197.27,31.22 197.8,30.69 197.8,30.42 197.13,29.75 197.13,25.6 195.55,24.01 195.55,21.63 196.04,21.14 196.04,16.79 195.84,16.59 194.82,16.59 194.73,16.51 194.73,16.33 194.82,16.25 195.84,16.25 196.04,16.05 196.04,15.51 195.54,15.01 195.26,15.01 194.9,15.37 194.77,15.37 194.65,15.25 194.65,15.13 195.01,14.76 195.01,14.49 194.58,14.05 192.96,14.05 v1(192.92,14.1)
M_B_CLK_DDR_DP<1>: length 93.4
  TOP w0.076: v1(211.68,65.83) U1.M42
  TOP w0.109: CN19.138 193.47,19.73 193.58,19.62 193.58,17.67 193.81,17.44 194.28,17.44 v1(194.47,17.25)
  ART03 w0.087: v1(211.68,65.83) 211.85,65.66 212.21,65.66 212.35,65.52 212.35,64.97 211.66,64.28 211.66,63.8 212.48,62.97 212.48,62.06 213.52,61.02 213.52,60.76 212.43,59.67 212.43,59.55 212.55,59.43 212.67,59.43 213.76,60.51 214.02,60.51 215.74,58.8 217.21,58.8 217.46,58.56 217.46,58.12 217.18,57.84 215.44,57.84 215.15,58.14 214.46,58.14 213.69,58.91 213.57,58.91 213.45,58.78 213.45,58.66 214.22,57.89 214.22,57.63 214,57.41 213.74,57.41 212.97,58.19 212.85,58.19 212.72,58.06 212.72,57.94 213.5,57.17 213.5,56.91 212.91,56.32 212.91,56.2 213.03,56.08 213.15,56.08 214.67,57.59 214.92,57.59 215.14,57.37 215.14,57.11 213.64,55.61 213.64,52.26 213.15,51.76 213.15,46.15 205.43,38.44 201.17,38.44 197.41,34.68 197.14,34.68 196.91,34.91 196.91,35.19 199.3,37.58 199.3,37.7 199.18,37.81 199.04,37.81 196.53,35.3 196.53,25.81 194.82,24.1 194.82,21.39 195.36,20.84 195.36,18.03 194.83,17.5 194.72,17.5 v1(194.47,17.25)
M_B_CS*<0>: length 97.9
  TOP w0.135: v1(208.93,65.83) 208.78,65.91 U1.V42 ; v1(197.6,8.41) 197.67,8.34 197.84,8.34 198.22,8.71 CN19.149
  ART03 w0.108: v1(197.6,8.41) 197.52,8.48 186.43,8.48 184.9,10.01 184.9,14.86 185.37,15.34 185.37,20.01 184.5,20.88 184.5,23.2 186.19,24.88 186.19,28.1 186.3,28.21 186.64,28.21 186.75,28.32 186.75,28.53 186.64,28.64 186.3,28.64 186.19,28.75 186.19,28.97 186.3,29.07 186.64,29.07 186.75,29.18 186.75,29.4 186.64,29.51 186.3,29.51 186.19,29.61 186.19,29.83 186.3,29.94 186.7,29.94 186.81,30.05 186.81,30.26 186.7,30.37 186.3,30.37 186.19,30.48 186.19,30.82 187.13,31.76 187.28,31.76 187.68,31.37 187.83,31.37 187.98,31.52 187.98,31.68 187.59,32.07 187.59,32.22 187.71,32.35 190.99,32.35 191.1,32.46 191.1,33.14 191.21,33.25 191.42,33.25 191.53,33.14 191.53,32.46 191.64,32.35 191.88,32.35 193.11,33.57 193.11,36.67 198.27,41.82 203.98,41.82 209.75,47.59 209.75,50.56 210.39,51.2 210.39,55.4 210.29,55.5 210.29,59.45 209.09,60.64 209.09,62.13 208.54,62.69 208.54,65.32 208.93,65.72 v1(208.93,65.83)
M_B_CS*<1>: length 95
  TOP w0.135: CN19.157 200.22,11.22 200.36,11.09 200.7,11.09 200.83,10.95 200.83,10.68 200.7,10.55 200.36,10.55 200.22,10.41 200.22,10.14 200.36,10.01 200.7,10.01 200.83,9.87 200.83,9.6 200.7,9.47 200.36,9.47 200.22,9.33 200.22,9.12 v1(200.28,9.07) ; v1(209.85,67.1) 209.84,67.1 209.4,67.35 U1.T39
  ART03 w0.108: v1(209.85,67.1) 209.48,66.73 209.48,64.62 209.2,64.34 209.2,63.07 209.74,62.53 209.74,61.79 210.84,60.68 210.84,55.94 211.16,55.61 211.16,52.27 211.03,52.14 211.03,50.86 210.68,50.51 210.68,47.16 204.41,40.89 198.65,40.89 194.07,36.31 194.07,33.22 192.25,31.39 189.78,31.39 189.52,31.13 189.52,30.17 189.63,30.06 190.07,30.06 190.19,29.94 190.19,29.73 190.09,29.63 189.92,29.63 187.27,26.98 187.27,24.37 187.38,24.26 187.63,24.26 187.74,24.16 187.74,23.94 187.63,23.83 187.38,23.83 187.27,23.72 187.27,22.59 186.44,21.77 186.44,19.43 186.98,18.89 186.98,17.95 186.4,17.36 186.4,14.75 185.98,14.34 185.98,13.31 186.36,12.93 186.36,11.25 188.2,9.41 199.93,9.41 v1(200.28,9.07)
M_B_CSA1_N: length 112.2
  TOP w0.135: CN19.162 201.47,18.17 201.55,18.1 201.55,18.08 201.8,17.84 201.81,17.84 202.55,17.09 203.87,17.09 203.97,17 v1(203.97,16.94) ; U1.V39 v1(208.92,67.1)
  ART03 w0.076: v1(208.92,67.1) 208.83,67.1 208.39,66.66 208.39,65.7 208.12,65.42 208.12,64.44
  ART03 w0.108: v1(203.97,16.94) 203.97,11.3 201.04,8.37 200.03,8.37 199.37,7.71 196.64,7.71 196.52,7.83 185.86,7.83 184.26,9.43 184.26,12.99 183.83,13.42 183.08,13.42 182.68,13.82 182.68,15.28 182.87,15.48 183.18,15.48 183.33,15.63 183.33,16.06 183.44,16.17 183.65,16.17 183.76,16.06 183.76,15.73 183.87,15.63 184.37,15.63 184.75,16 184.75,19.76 183.74,20.76 183.74,23.32 185.57,25.14 185.57,31.09 187.5,33.02 189.7,33.02 191.68,35.01 191.68,36.45 197.68,42.45 203.72,42.45 209.13,47.85 209.13,50.69 209.9,51.46 209.9,59.13 208.72,60.31 208.72,61.83 208.12,62.43 208.12,64.44
M_B_CSB0_N: length 112.2
  TOP w0.135: v1(201.99,8.56) 201.99,8.88 202.22,9.11 CN19.165 ; U1.Y39 v1(208.02,67.1)
  ART03 w0.087: 207.48,64.72 207.47,64.73 207.47,66.17 207.48,66.18 207.48,66.59 207.99,67.1 v1(208.02,67.1)
  ART03 w0.108: v1(201.99,8.56) 201.48,8.04 200.13,8.04 199.5,7.4 199.46,7.4 199.45,7.4 196.52,7.4 196.39,7.52 185.73,7.52 183.02,10.23 183.02,10.39 183.47,10.84 183.47,10.99 183.31,11.14 183.16,11.14 182.71,10.69 182.56,10.69 182.3,10.95 182.3,11.7 182.41,11.81 183.66,11.81 183.77,11.92 183.77,12.13 183.66,12.24 182.41,12.24 182.3,12.35 182.3,12.56 182.41,12.67 183.66,12.67 183.77,12.78 183.77,13 183.66,13.1 182.41,13.1 182.3,13.21 182.3,15.36 182.46,15.51 182.46,15.78 182.57,15.9 182.9,15.9 183.01,16 183.01,16.22 182.9,16.33 182.47,16.33 182.36,16.44 182.36,16.65 182.47,16.76 182.9,16.76 183.01,16.87 183.01,17.08 182.9,17.19 182.47,17.19 182.36,17.3 182.36,17.53 182.53,17.7 182.53,19.81 182.2,20.14 182.2,20.3 182.31,20.41 182.64,20.41 182.75,20.52 182.75,20.73 182.64,20.84 182.31,20.84 182.2,20.95 182.2,21.17 182.31,21.27 182.64,21.27 182.75,21.38 182.75,21.6 182.64,21.71 182.31,21.71 182.2,21.81 182.2,22.03 182.31,22.14 182.64,22.14 182.75,22.25 182.75,22.46 182.64,22.57 182.31,22.57 182.2,22.68 182.2,22.89 182.31,23 182.64,23 182.75,23.11 182.75,23.32 182.64,23.43 182.31,23.43 182.2,23.54 182.2,23.73 182.52,24.05 182.67,24.05 182.79,23.93 182.95,23.93 183.1,24.08 183.1,24.24 182.98,24.36 182.98,24.51 183.13,24.66 183.28,24.66 183.4,24.54 183.56,24.54 183.71,24.7 183.71,24.85 183.59,24.97 183.59,25.12 183.75,25.28 183.75,27.44 184.57,28.26 184.57,31.58 186.96,33.97 187.88,33.97 197.29,43.38 203.34,43.38 208.18,48.22 208.18,51.06 209.31,52.19 209.31,58.86 207.53,60.64 207.53,64.53 207.48,64.59 207.48,64.72
M_B_DQ<0>: length 76.8
  TOP w0.076: v1(204.38,56.41) 204.38,56.65 203.62,57.41 203.62,58.32 202.84,59.1 202.84,59.78 202.84,61.02 202.4,61.45 202.4,61.46 202.39,61.47 202.39,62.35 202.4,62.35 202.4,62.43 202.67,63 U1.AK48
  TOP w0.109: v1(170.22,13.8) CN19.45
  ART03 w0.087: v1(170.22,13.8) 169.65,14.38 169.65,16.29 169.74,16.38 170.05,16.38 170.14,16.46 170.14,16.64 170.05,16.72 169.74,16.72 169.65,16.81 169.65,16.98 169.74,17.07 170.05,17.07 170.14,17.16 170.14,17.33 170.05,17.42 169.74,17.42 169.65,17.5 169.65,17.76 170.33,18.44 170.33,27.88 170.26,27.96 170.26,32.91 179.44,42.09 184.37,42.09 192.98,50.7 199.38,50.7 200.86,52.19 202.15,52.19 202.48,52.51 202.48,56.71 202.74,56.97 203.82,56.97 v1(204.38,56.41)
M_B_DQ<1>: length 76.6
  TOP w0.076: v1(204.43,55.74) 204,56.18 204,56.78 203.37,57.41 203.37,58.25 202.68,58.94 202.68,59.03 202.67,59.03 202.67,60.91 202.64,60.98 202.24,61.38 202.24,61.39 202.23,61.4 202.23,62.42 202.23,62.42 202.23,62.55 202.27,62.59 202.27,62.79 202.34,62.86 202.34,63.8 202.66,64.12 U1.AK45
  TOP w0.109: CN19.50 171.43,20.67 171.43,19.29 v1(170.97,18.84)
  ART03 w0.087: v1(170.97,18.84) 171.36,19.22 171.36,19.59 170.68,20.27 170.68,23.09 170.76,23.17 170.94,23.17 171.02,23.09 171.02,20.56 171.11,20.48 171.28,20.48 171.37,20.56 171.37,23.43 171.1,23.7 171.1,27.64 170.6,28.13 170.6,32.72 179.64,41.75 184.61,41.75 193.31,50.46 199.55,50.46 201.01,51.91 202.18,51.91 203.73,53.47 203.73,55.04 v1(204.43,55.74)
M_B_DQ<2>: length 76
  TOP w0.076: v1(204.47,54.52) 204.76,54.52 204.96,54.72 204.96,56.34 204.73,56.56 204.73,56.56 204.53,56.77 204.52,56.77 203.86,57.43 203.86,57.43 203.84,57.46 203.84,57.46 203.81,57.49 203.81,58.38 203.03,59.16 203.03,59.18 203.03,59.18 203.03,59.2 203.03,59.21 203.03,61.06 202.57,61.52 202.57,61.53 202.56,61.54 202.56,62.28 U1.AK49
  TOP w0.109: CN19.46 170.47,18.76 v1(170.97,18.26)
  ART03 w0.087: v1(170.97,18.26) 170.59,17.88 170.59,17.52 170.85,17.27 171.16,17.27 171.74,17.85 171.74,20.4 171.9,20.56 171.9,24.01 171.81,24.1 171.54,24.1 171.46,24.18 171.46,24.36 171.54,24.44 171.81,24.44 171.9,24.53 171.9,24.78 171.46,25.22 171.46,28.05 171.37,28.14 171.1,28.14 171.01,28.23 171.01,28.4 171.1,28.49 171.37,28.49 171.46,28.57 171.46,28.75 171.37,28.83 171.06,28.83 170.96,28.93 170.96,29.1 171.04,29.18 171.37,29.18 171.46,29.27 171.46,31.49 171.37,31.58 171.06,31.58 170.97,31.66 170.97,31.84 171.06,31.92 171.37,31.92 171.46,32.01 171.46,32.18 171.37,32.27 171.06,32.27 170.97,32.36 170.97,32.53 171.06,32.62 171.37,32.62 171.46,32.7 171.46,32.97 179.9,41.41 184.94,41.41 193.65,50.12 199.72,50.12 201.15,51.54 202.19,51.54 203.91,53.26 203.91,54.38 204.05,54.52 v1(204.47,54.52)
M_B_DQ<3>: length 75.5
  TOP w0.076: v1(205.97,54.32) 206.59,54.94 206.59,56.1 206.59,56.1 206.59,56.51 206.59,57.54 204.25,59.88 204.25,61.11 204.34,61.2 204.34,62.57 204.31,62.6 204.23,62.78 204.23,63.38 U1.AG47
  TOP w0.109: CN19.59 v1(173.72,13.84)
  ART03 w0.087: v1(205.97,54.32) 205.85,54.32 205.63,54.09 205.63,52.59 203.46,50.42 203.46,50.28 201.04,47.86 194.8,47.86 185.88,38.94 181.72,38.94 174.08,31.3 174.08,29.39 174.62,28.85 174.62,24.79 174.85,24.57 174.85,17.17 174.64,16.97 173.9,16.97 173.63,17.24 173.51,17.24 173.38,17.12 173.38,17 173.66,16.72 173.66,16.6 173.53,16.48 173.41,16.48 173.14,16.75 173.02,16.75 172.89,16.63 172.89,16.5 173.17,16.23 173.17,16.11 172.99,15.93 172.99,14.57 v1(173.72,13.84)
M_B_DQ<4>: length 77
  TOP w0.076: v1(204.5,53.91) 204.92,53.91 205.15,54.14 205.15,56.38 204.9,56.62 204.9,56.63 204.6,56.93 204.59,56.93 204.03,57.5 204.03,57.5 204,57.53 204,58.44 203.2,59.25 203.2,59.27 203.19,59.27 203.19,59.9 203.19,61.13 202.73,61.59 202.73,61.62 202.73,61.63 202.73,61.76 202.73,62.07 202.9,62.24 202.9,62.5 202.89,62.53 202.88,62.54 202.88,62.81 202.89,62.87 202.9,62.93 202.9,63.18 202.66,63.42 U1.AK47
  TOP w0.109: CN19.49 171.22,15.96 170.92,16.27 170.43,16.27 170.22,16.06 v1(170.22,15.55)
  ART03 w0.087: v1(204.5,53.91) 204.14,53.56 204.14,53.18 202.17,51.21 201.31,51.21 199.85,49.76 193.91,49.76 185.22,41.06 180.04,41.06 171.82,32.84 171.82,27.94 172.28,27.49 172.28,20.36 172.08,20.17 172.08,17.41 171.29,16.62 171.17,16.62 171.05,16.73 170.92,16.73 170.81,16.61 170.81,16.49 170.92,16.37 170.92,16.25 v1(170.22,15.55)
M_B_DQ<5>: length 75.9
  TOP w0.076: v1(206,53.68) 205.95,53.72 205.9,53.72 205.35,54.27 205.35,56.41 205.07,56.69 205.07,56.7 204.66,57.1 204.66,57.1 204.19,57.57 204.19,58.51 203.36,59.34 203.36,59.83 203.36,59.83 203.36,61.21 203.34,61.25 202.89,61.69 202.89,62 203.11,62.21 203.11,62.48 203.05,62.62 203.05,62.75 203.08,62.87 203.08,63.18 202.96,63.49 202.96,64.1 203.19,64.33 U1.AG45
  TOP w0.109: CN19.63 v1(174.72,13.84)
  ART03 w0.087: v1(174.72,13.84) 175.09,13.84 175.2,13.95 175.2,16.03 175.28,16.12 175.77,16.12 175.85,16.21 175.85,16.38 175.77,16.47 175.28,16.47 175.2,16.55 175.2,16.73 175.28,16.81 175.87,16.81 175.95,16.89 175.95,17.06 175.85,17.16 175.28,17.16 175.2,17.25 175.2,24.73 174.98,24.95 174.98,31.65 181.92,38.59 186.06,38.59 194.92,47.46 201.16,47.46 203.85,50.15 203.85,50.56 203.84,50.57 206,52.72 v1(206,53.68)
M_B_DQ<6>: length 75.1
  TOP w0.076: v1(205.92,55.62) 205.98,55.62 206.42,56.06 206.42,56.44 206.42,56.44 206.42,57.47 204.06,59.83 204.06,61.15 204.18,61.27 204.18,62.48 204.16,62.51 204.15,62.52 204.15,62.53 204.06,62.62 204.06,62.73 U1.AG48
  TOP w0.109: CN19.58 173.47,18.17 v1(173.97,17.67)
  ART03 w0.087: v1(205.92,55.62) 205.46,55.16 205.46,52.72 203.89,51.14 203.62,51.14 203.04,50.57 203.04,50.34 200.93,48.23 194.67,48.23 185.78,39.34 181.62,39.34 173.73,31.46 173.73,29.17 174.27,28.62 174.27,28.3 174.19,28.21 173.84,28.21 173.75,28.13 173.75,27.95 173.84,27.87 174.19,27.87 174.27,27.78 174.27,24.64 174.49,24.42 174.49,22.97 174.4,22.88 174.23,22.88 174.14,22.97 174.14,24.2 174.05,24.29 173.88,24.29 173.79,24.2 173.79,22.62 173.88,22.54 174.32,22.54 174.49,22.37 174.49,17.78 174.27,17.57 174.08,17.57 v1(173.97,17.67)
M_B_DQ<7>: length 74.2
  TOP w0.076: v1(205.9,56.25) 206.26,56.61 206.26,57.4 203.89,59.76 203.89,61.22 204.01,61.34 204.01,62.29 U1.AG49
  TOP w0.109: CN19.62 174.47,19.2 174.12,18.84 v1(173.97,18.84)
  ART03 w0.087: v1(173.97,18.84) 174.11,18.98 174.11,21.07 173.39,21.79 173.39,32.28 175.27,34.16 175.9,34.16 176.03,34.28 176.03,34.41 175.83,34.6 175.83,34.72 175.95,34.85 176.08,34.85 176.27,34.65 176.39,34.65 176.52,34.77 176.52,34.9 176.32,35.09 176.32,35.21 176.44,35.34 176.57,35.34 176.76,35.14 176.88,35.14 177.01,35.26 177.01,35.39 176.81,35.58 176.81,35.7 176.93,35.83 177.06,35.83 177.25,35.63 177.37,35.63 177.5,35.75 177.5,35.88 177.3,36.07 177.3,36.19 177.42,36.32 177.55,36.32 177.74,36.12 177.86,36.12 177.99,36.24 177.99,36.37 177.79,36.56 177.79,36.68 177.91,36.81 178.04,36.81 178.23,36.61 178.35,36.61 178.48,36.74 178.48,36.86 178.28,37.05 178.28,37.17 178.4,37.3 178.53,37.3 178.72,37.1 178.84,37.1 178.97,37.23 178.97,37.35 178.77,37.54 178.77,37.67 178.89,37.79 179.02,37.79 179.21,37.59 179.33,37.59 179.46,37.72 179.46,37.84 179.26,38.03 179.26,38.16 179.38,38.28 179.51,38.28 179.7,38.08 179.82,38.08 179.95,38.21 179.95,38.33 179.75,38.52 179.75,38.65 179.87,38.77 180,38.77 180.19,38.57 180.31,38.57 180.44,38.7 180.44,38.82 180.24,39.01 180.24,39.14 180.94,39.84 185.74,39.84 194.51,48.6 200.67,48.6 202.49,50.42 203.48,51.41 203.87,51.41 205.27,52.81 205.27,55.62 v1(205.9,56.25)
M_B_DQ<8>: length 85.1
  TOP w0.076: U1.AJ38 203.38,67.77 v1(203.44,67.73)
  TOP w0.109: CN19.21 v1(164.22,13.8)
  ART03 w0.087: v1(164.22,13.8) 164.12,13.7 163.89,13.7 163.61,13.97 163.61,15.2 164.2,15.79 164.2,20.2 163.85,20.55 163.85,26.89 164.13,27.17 164.13,33.94 177.36,47.17 182.62,47.17 187.54,52.09 187.54,57.05 189.21,58.72 189.21,59.34 189.48,59.61 189.6,59.61 189.79,59.42 189.91,59.42 190.03,59.54 190.03,59.67 189.84,59.86 189.84,59.98 189.97,60.1 190.09,60.1 190.33,59.86 190.45,59.86 190.57,59.98 190.57,60.11 190.33,60.35 190.33,60.47 190.46,60.59 190.58,60.59 190.77,60.4 190.89,60.4 191.01,60.52 191.01,60.65 190.82,60.84 190.82,60.96 191.09,61.22 201.45,61.22 204.07,63.84 204.07,64.16 204.21,64.3 204.21,65.45 204,65.66 204,67.18 v1(203.44,67.73)
M_B_DQ<9>: length 85.2
  TOP w0.076: U1.AL39 202.43,67.15 v1(202.53,67.1)
  TOP w0.109: v1(159.38,17.57) 160.01,17.57 160.97,18.53 CN19.8
  ART03 w0.087: v1(159.38,17.57) 159.61,17.8 159.78,17.8 160.23,18.25 160.23,24.04 159.97,24.3 159.97,28.68 160.26,28.97 160.26,34.77 175.78,50.29 180.54,50.29 182.76,52.52 182.76,60.04 185.76,63.05 186.8,63.05 187.9,64.15 188.88,64.15 189.28,64.56 192.42,64.56 192.68,64.3 192.68,64.07 192.77,63.98 192.94,63.98 193.02,64.06 193.02,64.47 193.11,64.56 193.28,64.56 193.37,64.47 193.37,64.07 193.46,63.98 193.63,63.98 193.72,64.06 193.72,64.36 193.91,64.56 200.24,64.56 200.38,64.41 200.99,64.41 202.15,65.57 202.15,66.72 v1(202.53,67.1)
M_B_DQ<10>: length 84.5
  TOP w0.076: U1.AJ39 203.34,67.15 v1(203.44,67.1)
  TOP w0.109: CN19.16 162.97,19.32 163.45,18.84 v1(163.47,18.84)
  ART03 w0.087: v1(163.47,18.84) 163.86,19.23 163.86,19.97 163.49,20.34 163.49,28.58 163.76,28.84 163.76,34.22 177.06,47.52 182.41,47.52 187.11,52.22 187.11,57.72 187.41,58.01 187.53,58.01 187.76,57.79 187.88,57.79 188,57.91 188,58.03 187.77,58.26 187.77,58.38 187.9,58.5 188.02,58.5 188.25,58.28 188.37,58.28 188.49,58.4 188.49,58.52 188.26,58.75 188.26,58.87 188.39,58.99 188.51,58.99 188.74,58.77 188.86,58.77 188.98,58.89 188.98,59.01 188.75,59.24 188.75,59.36 190.79,61.4 191.24,61.4 191.33,61.48 191.33,61.79 191.41,61.88 191.59,61.88 191.67,61.79 191.67,61.48 191.76,61.4 191.93,61.4 192.02,61.48 192.02,61.79 192.11,61.88 192.28,61.88 192.37,61.79 192.37,61.48 192.45,61.4 193.87,61.4 193.96,61.48 193.96,61.85 194.04,61.93 194.22,61.93 194.3,61.85 194.3,61.48 194.39,61.4 194.56,61.4 194.65,61.48 194.65,61.85 194.74,61.93 194.91,61.93 195,61.85 195,61.48 195.08,61.4 196.52,61.4 196.61,61.48 196.61,61.75 196.69,61.83 196.87,61.83 196.95,61.75 196.95,61.48 197.04,61.4 197.21,61.4 197.3,61.48 197.3,61.75 197.39,61.83 197.56,61.83 197.65,61.75 197.65,61.55 197.8,61.4 201.33,61.4 201.38,61.45 203.86,63.93 203.86,64.69 204.04,64.87 204.04,65.37 203.82,65.59 203.82,66.72 v1(203.44,67.1)
M_B_DQ<11>: length 85.1
  TOP w0.076: U1.AL43 202.44,65.23 v1(202.48,65.13)
  TOP w0.109: CN19.3 159.72,14.01 v1(160.24,14.53)
  ART03 w0.087: v1(160.24,14.53) 160.82,15.11 160.82,15.56 161.02,15.76 161.02,24.36 160.76,24.62 160.76,27.97 160.97,28.18 160.97,34.35 176.09,49.47 181.16,49.47 183.48,51.79 183.48,57.86 183.57,57.94 183.74,57.94 183.83,57.86 183.83,56.73 183.92,56.65 184.09,56.65 184.18,56.73 184.18,58.2 184.09,58.29 183.57,58.29 183.48,58.38 183.48,58.83 188.09,63.43 200.73,63.43 202.43,65.12 202.47,65.12 v1(202.48,65.13)
M_B_DQ<12>: length 85
  TOP w0.076: v1(202.53,67.73) 202.41,67.8 U1.AL38
  TOP w0.109: CN19.4 159.97,19.15 159.67,18.84 v1(159.47,18.84)
  ART03 w0.087: v1(202.53,67.73) 202.13,67.33 202.13,67.02 201.97,66.87 201.97,65.69 201.05,64.76 187.14,64.76 182.45,60.07 182.45,53.62 182.16,53.32 181.89,53.32 179.8,51.24 179.8,51.12 179.93,50.99 180.05,50.99 181.4,52.35 181.53,52.35 181.65,52.23 181.65,52.11 180.23,50.69 175.68,50.69 159.87,34.88 159.87,29.22 159.62,28.97 159.62,23.75 159.88,23.49 159.88,19.25 v1(159.47,18.84)
M_B_DQ<13>: length 84
  TOP w0.076: v1(203.46,65.83) 203.4,65.86 203.01,66.06 U1.AJ42
  TOP w0.109: v1(163.47,17.67) 163.97,18.17 CN19.20
  ART03 w0.087: v1(203.46,65.83) 203.46,65.7 203.87,65.29 203.87,64.98 203.65,64.76 203.65,64 201.84,62.19 189.78,62.19 189.65,62.06 189.65,61.94 189.8,61.78 189.8,61.66 189.68,61.54 189.55,61.54 189.4,61.69 189.28,61.69 188.61,61.02 188.61,60.9 188.98,60.53 188.98,60.41 187.86,59.29 187.74,59.29 187.61,59.41 187.61,59.54 188.49,60.41 188.49,60.53 188.37,60.66 188.24,60.66 187.19,59.6 187.19,58.48 186.63,57.92 186.63,52.26 182.25,47.88 176.84,47.88 162.98,34.02 162.98,27.69 163.14,27.53 163.14,23.16 163.04,23.06 163.04,18.11 v1(163.47,17.67)
M_B_DQ<14>: length 83.8
  TOP w0.076: v1(202.51,65.79) 202.5,65.81 202.09,66.02 U1.AL42
  TOP w0.109: v1(160.24,15.32) 160.72,14.83 CN19.7
  ART03 w0.087: v1(202.51,65.79) 202.51,65.69 202.1,65.29 202.1,65.16 200.57,63.64 191.24,63.64 191.15,63.72 191.15,63.94 191.07,64.02 190.89,64.02 190.81,63.94 190.81,63.72 190.72,63.64 190.55,63.64 190.46,63.72 190.46,63.94 190.37,64.02 190.2,64.02 190.11,63.94 190.11,63.72 190.03,63.64 187.67,63.64 186.79,62.75 185.86,62.75 183.14,60.03 183.14,52.26 180.78,49.9 175.91,49.9 160.62,34.62 160.62,28.57 160.41,28.36 160.41,24.43 160.67,24.17 160.67,15.91 160.45,15.69 160.45,15.52 v1(160.24,15.32)
M_B_DQ<15>: length 83.8
  TOP w0.076: v1(203.46,65.19) 203.39,65.23 203,65.41 U1.AJ43
  TOP w0.109: v1(162.72,14.39) 163.22,13.89 CN19.17
  ART03 w0.087: v1(162.72,14.39) 163.13,14.79 163.13,16.19 162.61,16.71 162.61,24.61 162.35,24.87 162.35,26.78 162.55,26.98 162.55,34.11 176.69,48.25 182.04,48.25 185.59,51.8 185.59,58.45 186.54,59.4 186.54,59.53 186.42,59.65 186.3,59.65 185.76,59.11 185.64,59.11 185.51,59.23 185.51,59.35 186.58,60.41 187.56,60.41 189.67,62.52 201.77,62.52 203.46,64.21 v1(203.46,65.19)
M_B_DQ<16>: length 71.1
  TOP w0.076: v1(208.53,55.54) 208.96,55.97 208.96,56.37 208.96,56.38 208.96,57.56 208.37,58.15 208,58.15 206.33,59.83 206.33,61.28 206.52,61.47 206.52,62.13 206.52,62.14 206.52,62.29 U1.AB49
  TOP w0.109: CN19.83 179.72,14.69 180.04,15.01 v1(180.22,15.01)
  ART03 w0.087: v1(208.53,55.54) 208.15,55.16 208.15,52.69 206.74,51.28 206.74,48.76 202.53,44.55 196.72,44.55 187.57,35.4 184.76,35.4 180.72,31.37 180.72,24.58 180.27,24.12 180.27,21.43 180.19,21.35 179.83,21.35 179.74,21.26 179.74,21.09 179.83,21 180.19,21 180.27,20.91 180.27,20.74 180.19,20.65 179.83,20.65 179.74,20.57 179.74,20.39 179.83,20.31 180.19,20.31 180.27,20.22 180.27,18.33 179.45,17.52 179.45,15.51 179.96,15.01 v1(180.22,15.01)
M_B_DQ<17>: length 71
  TOP w0.076: U1.AB48 206.65,62.56 206.65,62.52 206.67,62.5 206.68,62.45 206.68,62.45 206.68,62.37 206.68,62.36 206.68,62.2 206.69,62.2 206.69,61.41 206.49,61.21 206.49,59.89 208.07,58.32 208.44,58.32 209.13,57.63 209.13,57.62 209.14,57.61 209.14,54.93 v1(208.54,54.32)
  TOP w0.109: v1(181.48,17.67) 180.31,17.67 179.97,18 CN19.84
  ART03 w0.087: v1(181.48,17.67) 180.98,18.18 180.98,20.59 181.06,20.67 181.24,20.67 181.32,20.59 181.32,19.96 181.41,19.87 181.58,19.87 181.67,19.96 181.67,21.52 181.58,21.6 181.28,21.6 180.98,21.9 180.98,23.7 182.44,25.17 182.44,32.05 185.09,34.7 187.87,34.7 197.04,43.87 202.82,43.87 207.47,48.52 207.47,51.26 208.51,52.3 208.51,53.12 208.92,53.53 208.92,54.06 208.66,54.32 v1(208.54,54.32)
M_B_DQ<18>: length 71.8
  TOP w0.076: v1(207.32,57.35) 207.14,57.53 207.14,57.71 205.49,59.36 205.49,59.45 205.48,59.46 205.48,59.47 205.48,59.48 205.48,59.84 205.48,60.94 205.08,61.34 205.08,62.3 U1.AE49
  TOP w0.109: CN19.70 176.47,18.17 v1(175.97,17.67)
  ART03 w0.087: v1(207.32,57.35) 207.14,57.35 206.58,56.8 206.58,52.82 204.55,50.8 204.55,49.71 201.55,46.71 195.51,46.71 186.42,37.62 182.7,37.62 182.2,37.12 182.2,36.87 182.31,36.76 182.31,36.63 182.19,36.51 182.06,36.51 181.85,36.72 181.73,36.72 181.61,36.6 181.61,36.48 181.82,36.27 181.82,36.14 181.7,36.02 181.57,36.02 181.36,36.23 181.24,36.23 181.11,36.11 181.11,35.99 181.33,35.78 181.33,35.65 181.21,35.53 181.08,35.53 180.87,35.74 180.75,35.74 180.62,35.62 180.62,35.5 180.84,35.29 180.84,35.16 180.71,35.04 180.59,35.04 180.38,35.25 180.26,35.25 180.13,35.13 180.13,35.01 180.35,34.8 180.35,34.67 180.22,34.55 180.1,34.55 179.89,34.76 179.77,34.76 179.64,34.64 179.64,34.52 179.86,34.31 179.86,34.18 177.33,31.65 176.94,31.65 176.36,31.07 176.36,18.06 v1(175.97,17.67)
M_B_DQ<19>: length 72.5
  TOP w0.076: U1.AE47 204.86,63.38 204.86,62.93 204.77,62.84 204.77,62.59 204.76,62.57 204.76,62.44 204.75,62.44 204.75,61.2 205.15,60.81 205.15,59.98 205.15,59.34 205.15,59.33 205.15,59.32 205.16,59.32 205.16,59.22 206.75,57.62 206.75,56.58 206.75,56.58 206.75,56.17 v1(207.41,55.52)
  TOP w0.109: v1(177.72,15.01) 177.44,15.01 176.72,14.3 CN19.71
  ART03 w0.087: v1(177.72,15.01) 177.11,15.62 177.11,16.22 177.24,16.35 177.42,16.35 177.5,16.44 177.5,16.61 177.42,16.7 177.14,16.7 177.06,16.78 177.06,16.96 177.14,17.04 177.42,17.04 177.5,17.13 177.5,17.3 177.42,17.39 177.14,17.39 177.06,17.48 177.06,27.31 177.82,28.07 177.82,30.92 183.79,36.89 186.72,36.89 195.82,45.99 201.8,45.99 205.27,49.46 205.27,50.99 206.93,52.65 206.93,55.32 207.12,55.52 v1(207.41,55.52)
M_B_DQ<20>: length 72.6
  TOP w0.076: v1(207.42,56.14) 206.92,56.65 206.92,57.69 205.32,59.29 205.32,59.39 205.32,59.39 205.32,59.4 205.32,59.41 205.32,59.91 205.32,60.87 204.92,61.27 204.92,62.37 204.92,62.37 204.92,62.51 204.92,62.51 204.94,62.52 204.94,62.54 U1.AE48
  TOP w0.109: v1(175.72,13.84) CN19.67
  ART03 w0.087: v1(207.42,56.14) 206.86,56.14 206.75,56.03 206.75,52.71 204.91,50.87 204.91,49.59 201.68,46.36 195.68,46.36 186.55,37.23 183.51,37.23 177.47,31.18 177.47,28.45 176.7,27.69 176.7,16.75 176.62,16.67 176.34,16.67 176.25,16.58 176.25,16.41 176.34,16.32 176.62,16.32 176.7,16.23 176.7,16.06 176.62,15.97 176.34,15.97 176.25,15.89 176.25,15.71 176.34,15.63 176.62,15.63 176.7,15.54 176.7,15.37 176.62,15.28 176.34,15.28 176.25,15.19 176.25,15.02 176.7,14.57 176.7,14.39 176.38,14.07 175.95,14.07 v1(175.72,13.84)
M_B_DQ<21>: length 71.6
  TOP w0.076: U1.AB47 206.43,63.66 206.2,63.17 206.2,62.84 206.21,62.78 206.21,62.61 206.19,62.5 206.19,62.23 206.35,62.06 206.35,61.54 206.16,61.35 206.16,59.76 207.93,57.99 208.3,57.99 208.8,57.49 208.8,56.45 v1(208.51,56.16)
  TOP w0.109: CN19.80 178.99,20.69 178.99,19.12 179.29,18.82 v1(179.48,18.82)
  ART03 w0.087: v1(179.48,18.82) 179,19.31 179,20.39 179.13,20.53 179.27,20.53 179.36,20.61 179.36,20.79 179.27,20.87 179.09,20.87 179,20.96 179,21.21 179.89,22.09 179.89,24.59 179.81,24.66 179.64,24.66 179.54,24.57 179.54,22.76 179.45,22.68 179.28,22.68 179.19,22.76 179.19,24.78 179.66,25.24 179.66,26.79 180.15,27.28 180.15,31.32 184.59,35.76 187.28,35.76 196.42,44.89 202.39,44.89 206.39,48.89 206.39,51.19 207.98,52.78 207.98,55.94 208.2,56.16 v1(208.51,56.16)
M_B_DQ<22>: length 71.3
  TOP w0.076: v1(208.54,53.71) 209.31,54.49 209.31,57.67 209.31,57.68 209.31,57.68 209.29,57.69 209.29,57.7 208.51,58.48 208.14,58.48 206.67,59.95 206.67,61.11 206.84,61.27 206.84,61.33 206.85,61.34 206.85,62.27 206.85,62.27 206.85,62.56 206.84,62.57 206.82,62.59 206.82,62.88 206.82,62.89 206.82,62.92 206.75,62.99 206.75,63.8 206.43,64.12 U1.AB45
  TOP w0.109: v1(180.22,16.18) 179.87,16.18 178.72,15.03 CN19.79
  ART03 w0.087: v1(180.22,16.18) 180.62,16.57 180.62,23.9 182.06,25.35 182.06,32.17 184.94,35.05 187.73,35.05 196.89,44.21 202.67,44.21 207.1,48.64 207.1,51.17 208.33,52.4 208.33,53.51 v1(208.54,53.71)
M_B_DQ<23>: length 72.5
  TOP w0.076: U1.AE45 205.9,64.33 206.09,64.14 206.09,63.5 206.03,63.45 206.03,62.78 206.03,62.78 206.03,62.61 206.02,62.6 206.02,62.16 206.19,62 206.19,61.61 206,61.42 206,59.69 206,59.69 206,59.67 207.91,57.76 208.23,57.76 208.37,57.63 v1(208.37,57.38)
  TOP w0.109: CN19.66 175.47,19.27 175.68,19.07 175.75,19.07 v1(175.97,18.84)
  ART03 w0.087: v1(208.37,57.38) 207.78,57.97 206.96,57.97 206.4,57.41 206.4,52.88 204.21,50.7 204.21,49.86 201.42,47.06 195.34,47.06 186.3,38.02 181.9,38.02 175.53,31.64 175.53,28.73 175.34,28.54 175.34,25.14 175.56,24.92 175.56,22.58 175.96,22.18 175.96,22.01 175.88,21.92 175.67,21.92 175.56,21.82 175.56,21.64 175.65,21.56 175.92,21.56 176,21.47 176,21.3 175.56,20.85 175.56,19.25 v1(175.97,18.84)
M_B_DQ<24>: length 81.3
  TOP w0.076: U1.AD38 205.74,68.01 v1(206.19,67.73)
  TOP w0.109: CN19.42 169.47,18.17 v1(168.97,17.67)
  ART03 w0.087: v1(206.19,67.73) 206.74,67.18 206.74,65.66 206.95,65.45 206.95,64.67 206.95,64.67 206.95,64.64 206.65,64.34 206.65,61.13 206.19,60.66 206.19,60.37 206.45,60.1 206.45,59.98 206.33,59.86 206.21,59.86 205.86,60.21 205.73,60.21 205.61,60.09 205.61,59.96 205.96,59.61 205.96,59.49 205.84,59.37 205.72,59.37 205.37,59.72 205.24,59.72 205.12,59.6 205.12,59.47 205.47,59.12 205.47,59 205.35,58.88 205.23,58.88 205.07,59.03 204.56,59.03 202.95,57.42 201.72,57.42 200.96,56.66 200.96,52.71 199.27,51.02 192.7,51.02 184.43,42.75 178.91,42.75 169.42,33.26 169.42,28.23 169.97,27.67 169.97,18.66 168.98,17.67 v1(168.97,17.67)
M_B_DQ<25>: length 82
  TOP w0.076: U1.AD39 206.13,67.13 v1(206.19,67.1)
  TOP w0.109: v1(168.97,18.84) 168.47,19.34 CN19.38
  ART03 w0.087: v1(168.97,18.84) 169.6,19.47 169.6,24.2 169.51,24.28 169.34,24.28 169.25,24.2 169.25,21.83 169.17,21.76 169,21.76 168.9,21.85 168.9,24.47 169.6,25.16 169.6,27.35 168.56,28.39 168.56,32.88 178.79,43.11 184.31,43.11 192.45,51.26 199.13,51.26 200.03,52.15 200.03,57.09 200.57,57.63 202.9,57.63 206.47,61.2 206.47,64.48 206.78,64.79 206.78,65.38 206.58,65.58 206.58,66.71 v1(206.19,67.1)
M_B_DQ<26>: length 81.9
  TOP w0.076: U1.AE39 205.19,67.14 v1(205.27,67.1)
  TOP w0.109: CN19.24 164.97,19.42 v1(164.98,19.41)
  ART03 w0.087: v1(164.98,19.41) 165.09,19.52 165.09,20.3 164.97,20.42 164.97,20.54 165.09,20.66 165.21,20.66 165.58,20.3 165.7,20.3 165.9,20.5 165.9,20.94 165.81,21.03 165.56,21.03 165.47,21.12 165.47,21.29 165.56,21.38 165.81,21.38 165.9,21.46 165.9,23.57 165.81,23.66 165.64,23.66 165.55,23.57 165.55,22.01 165.47,21.92 165.29,21.92 165.21,22.01 165.21,23.92 165.29,24.01 165.81,24.01 165.9,24.09 165.9,24.37 165.5,24.77 165.5,27.23 165.28,27.45 165.28,33.44 177.78,45.94 183.16,45.94 188.92,51.7 188.92,57.06 190.72,58.86 190.73,58.86 192.01,60.14 199.07,60.14 199.17,60.04 200.84,60.04 203.4,62.6 203.88,62.6 205.03,63.75 205.03,64.38 204.74,64.66 204.74,65.43 204.9,65.58 204.9,66.73 v1(205.27,67.1)
M_B_DQ<27>: length 83.8
  TOP w0.076: U1.AE43 205.27,65.19 v1(205.27,65.19)
  TOP w0.109: v1(166.22,13.8) CN19.29
  ART03 w0.087: v1(166.22,13.8) 166.02,13.8 165.84,13.98 165.84,16.84 165.93,16.93 166.1,16.93 166.19,16.84 166.19,16.04 166.28,15.96 166.45,15.96 166.54,16.04 166.54,17.19 166.45,17.27 165.93,17.27 165.84,17.36 165.84,19.38 167.02,20.56 167.02,24.29 166.66,24.65 166.66,28.1 166,28.76 166,31.21 166.2,31.41 166.44,31.41 166.53,31.49 166.53,31.67 166.44,31.75 166.08,31.75 166,31.84 166,32.01 166.08,32.1 166.44,32.1 166.53,32.19 166.53,32.36 166.44,32.45 166.33,32.45 166.22,32.56 166.22,33.22 178.12,45.12 183.39,45.12 190.34,52.07 190.34,57.45 192.57,59.69 198.46,59.69 198.59,59.56 201.88,59.56 205.38,63.06 205.38,64.71 205.27,64.82 205.27,65.19 v1(205.27,65.19)
M_B_DQ<28>: length 82.4
  TOP w0.076: v1(205.27,67.73) 205.23,67.76 U1.AE38
  TOP w0.109: CN19.25 v1(165.22,13.8)
  ART03 w0.087: v1(165.22,13.8) 164.74,14.28 164.74,15.28 164.55,15.47 164.55,16.13 164.63,16.22 164.81,16.22 164.9,16.3 164.9,16.48 164.81,16.56 164.63,16.56 164.55,16.65 164.55,24.91 164.71,25.08 164.71,27.52 164.93,27.73 164.93,33.62 177.72,46.42 183.12,46.42 188.6,51.9 188.6,57.27 191.69,60.35 198.31,60.35 198.8,60.84 201.4,60.84 203.37,62.81 203.8,62.81 204.85,63.85 204.85,64.3 204.58,64.58 204.58,65.5 204.72,65.64 204.72,67.18 v1(205.27,67.73)
M_B_DQ<29>: length 82.7
  TOP w0.076: U1.AD43 206.23,65.17 v1(206.23,65.16)
  TOP w0.109: v1(168.22,13.8) CN19.37
  ART03 w0.087: v1(168.22,13.8) 167.77,13.8 167.08,14.49 167.08,16.55 167.17,16.64 167.34,16.64 167.43,16.55 167.43,15.14 167.51,15.05 167.69,15.05 167.77,15.14 167.77,16.9 167.69,16.99 167.17,16.99 167.08,17.07 167.08,17.39 168.18,18.5 168.18,24.8 167.79,25.2 167.79,33.09 178.65,43.96 184.07,43.96 191.92,51.8 196.41,51.8 198.02,53.41 198.02,57.19 198.64,57.81 199.94,57.81 200.28,58.15 202.58,58.15 203.55,59.12 203.55,60.18 206.1,62.74 206.1,65.03 v1(206.23,65.16)

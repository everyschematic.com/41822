# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
+V1.05A_EN: length 174.3
  TOP w0.102: v1(151.31,101.06) 151.33,101.08 151.59,100.82 R378.1
  ART06 w0.102: v1(59.18,64.5) 57.57,66.11 56.66,66.11 55.79,66.98 55.79,72.82 54.93,73.67 51.71,73.67 50.66,72.62 49.26,72.62 48.69,72.06 47.48,72.06 46.06,73.48 46.06,74.07 44.76,75.36 44.76,77.56 43.79,78.53 43.79,79.19 45.58,80.98 46.99,80.98 47.28,81.27 48.79,81.27 49.83,80.23 56.24,80.23 57.72,78.75 59.88,78.75 60.53,79.4 60.53,82.05 58.62,83.96 58.62,86.49 61.64,89.51 61.64,92.36 62.87,93.59 63.43,93.59 65.25,95.4 65.25,106.24 67.66,108.66 74.02,108.66 75.97,106.7 79.53,106.7 83.8,102.43 93.75,102.43 94.89,103.58 121.84,103.58 125.42,107.16 131.66,107.16 133.52,105.29 137.31,105.29 138.29,106.28 139.34,106.28 139.93,105.68 143.37,105.68 143.97,105.07 147.56,105.07 151.31,101.33 v1(151.31,101.06)
  BOTTOM w0.102: R199.1 59.11,64.43 v1(59.18,64.5)
+V1.05A_EN_R: length 6.7
  TOP w0.203: U24.6 148.46,96.5 148.7,96.74 148.7,97.8 150.01,99.12 R194.2 150.54,99.77 C350.2 R378.2
  TOP w0.305: R378.2 151.61,99.47 R858.2
+V1.8A_PCH: length 7.2
  TOP w0.203: U1.DG17 v1(174.79,77.66) ; U1.DF18 v1(175.44,76.83) ; v1(175.72,69.74) 175.5,69.96 U1.DF34 ; U1.DF15 v1(175.44,78.49) ; U1.DG18 v1(174.79,76.83) 174.79,76.73 U1.DG20 ; U1.DF17 v1(175.44,77.66) ; U1.DD35 v1(176.69,68.98) ; v1(175.44,76) U1.DF20
  BOTTOM w0.375: R96.1 176.95,77.57
  BOTTOM w0.508: 176.95,77.57 176.95,77.84 176.55,78.25 175.83,78.25 175.76,78.18 175.62,78.31
+V1.8U_2.5U_MEM: length 4.6
  BOTTOM w0.305: R187.2 222.72,11.9 225.85,11.9 226.18,11.58 226.18,11 v1(226.22,11)
  vias: v2(225.55,11.07) v2(227.66,24.64) v2(227.67,23.92)
+V1P05A: length 27.1
  TOP w0.254: v1(163.33,81) R867.1
  ART06 w0.203: v1(155.02,89.85) 154.08,88.92 154.08,87.02 155.28,85.82 155.28,82.03 155.06,81.8 155.06,78.11 155.83,77.34 156.54,77.34 157.8,78.6 157.8,78.77 160.01,80.98 163.31,80.98 v1(163.33,81)
  BOTTOM w0.406: v1(155.02,89.85) 154.31,89.85 153.58,89.12 153.58,87.4 R800.2
  vias: v1(188.8,90.7) v2(155.44,90.39) v2(189.4,90.6)
+V1P05A_E: length 15.2
  TOP w0.305: R211.2 145.03,101.26 145.07,101.3 v1(145.07,101.33) R6.2
  ART06 w0.406: v1(153.59,93.08) 153.48,93.19 153.38,93.19 149.36,97.21 146.46,97.21 144.73,98.94 144.73,101 v1(145.07,101.33)
+V1P05S_VCCST: length 276
  TOP w0.203: U1.CB1 187.47,86.32 187.47,86.76 v1(187.95,87.24)
  TOP w0.305: 159.79,94.45 159.08,94.45 158.35,95.18 157.37,95.18 156.61,95.94 155.89,95.94 153.4,98.43 153.4,100.71 152.88,101.23 151.92,101.23 151.49,101.66 150.14,101.66 149.88,101.92 149.88,102.81 148.83,103.86 145.5,103.86 143.94,105.42 v1(143.94,106.88) ; 216.85,90.32 216.85,90.17 217.27,89.75 218.32,89.75 218.9,89.17 R124.1 ; 216.85,90.32 R129.1 ; 216.85,90.32 U13.5 v1(216.85,91.54) ; v1(183.26,89.4) 183.41,89.55 183.41,90.2 183.77,90.57 R98.1
  TOP w0.508: v1(163.08,92.27) 163.06,92.29 163.06,92.63 162.2,93.49
  ART03 w0.305: v1(187.95,87.24) 188.43,87.72 189.82,87.72 190.21,87.33 190.21,86.28 190.88,85.61 190.88,82.24 191.31,81.82 192.01,81.82 194.1,79.73 204.78,79.73 205.93,78.58 210.63,78.58 212.06,80.01 212.06,80.42 212.87,81.23 212.87,81.54 214.76,83.42 v1(214.76,84.6) 214.84,84.6 215.09,84.85 215.09,86.56 214.37,87.27 213.21,87.27 212.71,87.77 212.71,88.77 214.73,90.79 214.73,91.51 215.39,92.17 216.22,92.17 v1(216.85,91.54) ; v1(40.66,80.94) 41.76,79.84 47.7,79.84 48.43,79.11 48.43,77.69 49.06,77.06 55.12,77.06 55.81,77.76 57.06,77.76 57.32,78.01 60.69,78.01 61.13,78.44 79.79,78.44 80.04,78.69 86.67,78.69 89.08,81.1 89.08,91.28 90.48,92.69 103.32,92.69 105.99,95.36 105.99,97.15 105.07,98.06 105.07,101.22 105.91,102.06 110.26,102.06 114.13,105.92 123.15,105.92 123.87,106.63 130.06,106.63 131.33,105.36 131.33,104.33 131.99,103.68 137.83,103.68 138.8,104.65 139.38,104.65 141.54,106.81 143.87,106.81 v1(143.94,106.88)
  ART06 w0.508: 184.03,89.87 183.47,90.43 ; 184.03,89.87 185.04,88.86 185.04,88.28 186.08,87.24 v1(187.95,87.24) ; 184.03,89.87 183.73,89.87 183.47,89.61 ; 183.47,90.43 183.47,92.18 182.38,93.27 181.18,93.27 176.18,98.27 170.89,98.27 167.46,94.83 165.32,94.83 163.12,92.63 163.12,92.31 v1(163.08,92.27) ; 183.47,90.43 183.47,89.61 ; v1(226.72,93.16) 225.98,93.16 221.52,88.71 218.58,88.71 217.11,90.17 217.11,91.28 v1(216.85,91.54) ; v1(183.26,89.4) 183.47,89.61
  BOTTOM w0.305: v1(40.66,80.94) 40.66,82.34 39.81,83.19 R438.1 ; R65.1 225.91,94.52 225.91,93.18 C6137.1 226.19,93.12 226.67,93.12 v1(226.72,93.16) 227.44,93.89 R32.2 ; C6136.1 215.83,85.09 ; 215.83,85.09 215.36,85.56 R305.2 ; 215.83,85.09 215.24,85.09 v1(214.76,84.6) 214.76,84.33 214.58,84.15 212.91,84.15 212.53,84.54 R306.1
+V1P05S_VCCST_PWRGD: length 11.8
  BOTTOM w0.152: R836.2 41.22,84.39 41.22,79.33 41.71,78.84 42.75,78.84 43.36,78.23 U9.69
  BOTTOM w0.203: R836.2 41.18,84.68 42.85,86.36 Q48.3
+V1P05S_VCCSTG: length 38.6
  ART06 w0.508: v1(188.02,86.57) 187.91,86.57 186.7,85.37 180.84,85.37 180.07,86.14 180.07,93.26 175.7,97.64 171.31,97.64 167.55,93.89 165.38,93.89 163.82,92.33 163.82,91.94 163.41,91.53 162.86,91.53 162.47,91.92 162.47,92.17 v1(162.39,92.24)
+V1P8A: length 311.2
  TOP w0.3: U1.BM9 v1(192.46,82.41) ; v1(194.27,82.4) 194.22,82.35 194.19,82.35 U1.BG9 ; U1.BJ9 v1(193.35,82.41)
  TOP w0.305: R443.2 129.28,105.54 129.46,105.36 v1(129.53,105.36) ; v1(145.41,83.09) 144.88,83.09 R191.2 ; PR29.2 160.41,78.7 R177.2 R374.2 161.89,78.58 PR37.2 v1(162.19,78.3) ; R181.2 126.34,101.3 v1(126.25,101.39) 126.11,101.53 125.97,101.53 125.54,101.1 125.54,99.85 126.01,99.38 R466.2
  ART03 w0.305: v2(150.96,74.04) 148.77,74.04 147.8,73.07 144.34,73.07 142.91,71.64 137.55,71.64 133.38,67.48 127.45,67.48 123.8,63.83 118.93,63.83 117.15,62.05 108.66,62.05 108.27,61.65 99.66,61.65 99.01,61.01 91.43,61.01 90.89,61.55 81.19,61.55 80.6,62.14 75.62,62.14 74.14,63.62 64.14,63.62 63.29,64.47 61.26,64.47 61.05,64.68 60.62,64.68 59.32,63.39 56.08,63.39 54.89,64.58 51.86,64.58 51.73,64.71 44.5,64.71 43.91,65.29 41.66,65.29 40.56,64.19 40.56,59.67 39.44,58.55 39.44,55.66 39.91,55.19 42.37,55.19 44.19,57.02 46.06,57.02 46.53,57.48 51.46,57.48 51.91,57.04 v1(51.91,56.79) ; v1(153.64,82.67) 153.62,82.67 153.48,82.81 153.4,82.81 153.27,82.94 148.76,82.94 148.49,82.67 148.49,82.08 v1(148.57,82)
  ART06 w0.203: v2(151.7,74.09) 151.75,74.09 156.39,69.44 v1(157.69,69.44)
  ART06 w0.305: v1(129.53,105.36) 129.58,105.31 129.58,103.53 ; v1(147.74,74.59) 147.46,74.87 147.46,78.68 145.65,80.49 145.65,82.84 v1(145.41,83.09) ; v2(151.7,74.09) 150.74,75.05 150.74,80.67 149.91,81.51 149,81.51 148.57,81.94 v1(148.57,82) ; 129.58,103.53 129.44,103.38 127.94,103.38 126.25,101.7 v1(126.25,101.39) ; 129.58,103.53 129.73,103.39 141.65,103.39 143.51,101.52 143.51,99.26 146.2,96.57 149.29,96.57 151.79,94.08 151.79,86.53 153.25,85.07 153.25,82.94 153.38,82.81 153.48,82.81 153.62,82.67 v1(153.64,82.67)
  ART06 w0.508: 190.68,82.27 190.68,85.21 190.24,85.65 190.24,86.93 189.93,87.24 v1(189.56,87.24)
  ART06 w0.762: 168.7,78.14 171.33,78.14 171.7,78.51 173.72,78.51 174.66,79.44 182.8,79.44 183.4,80.04 183.4,81.04 183.92,81.56 189.26,81.56 189.8,82.1 190.88,82.1
  BOTTOM w0.152: v1(157.69,69.44) 158.2,68.93 158.2,66.89 157.77,66.46 157.77,62.37 159.35,60.8 162.32,60.8 164.27,58.85 164.27,57.98 166.88,55.37 171.12,55.37 171.71,55.96 174.67,55.96 175.72,57.01 175.72,59.55 176.36,60.2 176.37,60.2
  BOTTOM w0.305: v1(162.19,78.3) 162.19,79.09 ; 162.19,79.09 162.19,80.63 165.18,83.62 165.18,89.17 165.56,89.55 165.56,90.25 ; 162.19,79.09 162.18,79.09 161.83,78.74 ; 162.19,79.09 162.52,78.76 ; R834.1 v1(51.91,56.79) ; 165.56,90.25 R317.1 ; 165.56,90.25 R313.1
  vias: v2(165.46,78.74)
+V1P8S: length 253.7
  TOP w0.203: 29.01,76.2 29.59,76.78 U25.40
  TOP w0.305: 24.19,72.11 24.19,72.1 23.91,71.82 ; 24.19,72.11 23.91,72.11 23.91,72.12 ; 24.19,72.11 23.91,72.4 ; 24.19,72.11 28.33,72.11 29.05,72.83 C469.1 28.44,74.53 C468.2 29.01,75.49 29.01,76.2 ; v1(151.62,71.12) 150.98,70.49 150.94,70.49 150.86,70.41 149.09,70.41 ; 149.09,70.41 148.71,70.41 148.63,70.49 ; 149.09,70.41 148.79,70.7
  TOP w0.406: v1(38.03,74.51) 37.82,74.3 FB31.2 ; FB25.2 24.71,70 24.7,69.99 ; v1(28.84,66.93) 27.76,66.93 24.7,69.99 ; 24.7,69.99 23.91,70.78 FB17.2
  ART03 w0.305: v1(156.93,71.63) 156.9,71.66 152.15,71.66 v1(151.62,71.12) 151.62,70.93 148.9,68.21 142.39,68.21 141.64,68.96 138.3,68.96 137.56,68.23 137.56,67.38 134.74,64.55 131.77,64.55 131.3,65.02 130.45,65.02 126.79,61.36 124.33,61.36 124.1,61.14 122.67,61.14 122.25,61.14 121.52,60.41 v1(119.41,60.41) ; v1(43.13,74.29) 42.99,74.44 38.1,74.44 v1(38.03,74.51)
  ART06 w0.305: v1(119.41,60.41) 117.84,58.84 114.72,58.84 114.11,58.23 113.01,58.23 112.41,57.63 108.29,57.63 107.71,58.21 104.07,58.21 101.57,60.71 94,60.71 91.75,58.47 77.39,58.47 76.09,59.76 71.98,59.76 71.41,60.34 59.87,60.34 58.64,61.58 54.05,61.58 52.4,63.22 52.4,64.91 51.9,65.41 51.9,66.82 49.98,68.74 47.98,68.74 47.21,69.51 46.34,69.51 43.66,72.2 43.66,73.77 v1(43.13,74.29)
  ART06 w0.406: v1(28.84,66.93) 34.01,66.93 37.92,70.83 37.92,74.4 v1(38.03,74.51)
  BOTTOM w0.152: v1(156.93,71.63) 154.76,73.8 154.76,75.58 155.1,75.92 155.54,75.92 156.04,75.42 156.04,74.89 156.81,74.12 157.34,74.12 158.01,73.45 159.61,73.45 160.49,72.57 163.48,72.57 164.32,73.4 R404.2
  BOTTOM w0.305: v1(151.62,71.12) 151.41,70.92 151.41,62.4 152.04,61.77 152.04,60.97 153.32,59.7 R46.2 ; R665.1 R664.1 179.09,61.49 176.28,58.68 176.28,56.77 174.88,55.37 172.42,55.37 170.54,53.49 167.05,53.49 165.61,54.93 165.61,56.11 164.02,57.7 163.85,57.7 163.12,58.43 163.12,59.17 161.9,60.38 159.18,60.38 157.4,62.17 157.4,67.05 157.12,67.33 157.12,71.44 v1(156.93,71.63)
+V3.3_LAN: length 44.9
  TOP w0.305: R813.2 76.9,73.43 v1(76.92,73.41)
  TOP w0.508: v2(70.01,59.65) 69.12,60.54 69.12,73.37 v1(69.26,73.52) ; v2(70.79,59.64) 70.79,61.57 74.89,65.67 v1(79.22,65.67)
  ART03 w0.305: v1(76.92,73.41) 76.17,74.16 69.91,74.16 v1(69.26,73.52)
  BOTTOM w0.203: 75.8,71.55 75.58,71.33 U30.11
  BOTTOM w0.305: v1(79.22,65.67) 79.22,65.67 U18.5 ; R351.2 72.23,64.75 72.17,64.69 72.17,63.19 70.33,61.36 ; v1(76.92,73.41) 76.92,73.02 C416.1 76.74,72.85 C417.1 76.32,72.07 75.8,71.55
+V3.3_WIFI: length 9.3
  TOP w0.305: R240.2 126.22,93.79 125.81,93.38 124.93,93.38 124.58,93.72 v1(124.58,93.86) ; R420.2 124.21,103.37 ; 124.21,103.37 123.88,103.7 ; 124.21,103.37 124.19,103.37 ; 124.19,103.37 123.63,103.37 ; 124.19,103.37 123.86,103.04
  BOTTOM w0.305: v2(127.76,91.01) 128.97,92.22 128.97,93.45 128.66,93.76 U10.5 ; R248.2 124.58,95.49
  vias: v2(122.02,99.12) v2(122.77,99.15) v2(126.84,91.01)
+V3.3A_KBC: length 146.4
  TOP w0.305: 42.7,71.95 45.32,71.95 45.92,72.54 R359.1 ; 43.34,77.16 43.36,77.14 R360.1
  TOP w0.406: C341.1 58.6,74.62 v1(58.54,74.55) 58.54,70.9 v1(59.54,69.89) 59.54,69.75 59.02,69.22 59.02,68.17 59.61,67.58 59.61,67.33 v1(59.84,67.1) ; v1(54.4,59.5) 54.22,59.68 54.22,62.27 54.59,62.64 v1(54.59,64)
  TOP w0.508: v1(42.61,70.47) 42.61,71.02 42.7,71.11 42.7,71.95 42.44,72.21 42.44,74.72 43.34,75.63 43.34,79.59 44.03,80.28 v1(44.03,82.49)
  ART03 w0.305: 46.86,59.82 47.12,60.08 v1(47.15,60.08) ; v1(47.15,60.08) 47.15,59.83 47.14,59.82 ; v1(47.15,60.08) 47.18,60.08 47.44,59.82 ; v1(54.59,64) 56.02,62.57 58.02,62.57 v1(58.51,62.07) ; v1(40.06,56.11) 40.73,56.11 41.26,56.64 41.26,57.99 41.74,58.47 43.98,58.47 v1(44.47,57.98)
  ART03 w0.406: v1(44.47,57.98) 44.47,59.49 ; 44.47,59.49 44.47,59.73 44.38,59.82 ; 44.47,59.49 44.8,59.82 ; v1(44.06,61.33) 44.06,61.29 44.16,61.2 44.16,60.04 44.38,59.82 ; v1(59.84,67.1) 58.61,67.1 57.37,65.87 54.6,65.87 v1(54.33,66.13) ; 44.8,59.82 44.38,59.82 ; 44.8,59.82 54.07,59.82 v1(54.4,59.5)
  ART06 w0.305: v1(59.94,72.55) 59.78,72.72 59.78,73.31 v1(58.54,74.55) ; v1(54.35,69.01) 54.39,69.05 v1(54.39,70.41)
  ART06 w0.406: v1(54.59,64) 54.59,65.87 v1(54.33,66.13) 54.35,66.16 v1(54.35,69.01) ; v1(59.88,80.02) 59.25,80.65 58.64,80.65 58.1,81.19 53.02,81.19 v1(52.45,80.62) 52.34,80.73 49.86,80.73 48.92,81.66 46.69,81.66 v1(46.49,81.47)
  BOTTOM w0.203: v1(42.61,70.47) 42.59,70.45 U9.50 ; v1(54.33,66.13) 54.33,66.34 54.45,66.45 U9.121 ; v1(54.35,69.01) 54.67,69.01 54.91,69.25 U9.114 ; v1(44.06,61.33) 44.09,61.33 44.16,61.41 U9.26 ; v1(54.39,70.41) 54.39,70.34 54.68,70.05 U9.112 ; U9.92 52.56,78.54 ; U9.127 54.65,64.05 v1(54.59,64)
  BOTTOM w0.305: v1(47.15,60.08) 47.1,60.03 47.1,58.96 47.56,58.5 R238.2 ; R836.1 43.1,84.43 R1388.2 43.11,83.41 v1(44.03,82.49) ; v1(58.51,62.07) 58.48,62.1 R352.1 58.48,62.7 ; R48.1 59.63,72.87 v1(59.94,72.55) ; v1(52.45,80.62) 52.45,78.65 52.56,78.54 ; R105.1 R88.1 48.83,81.13 48.54,81.42 46.54,81.42 v1(46.49,81.47) ; R835.1 59.31,70.12 v1(59.54,69.89) ; v1(59.84,67.1) 59.84,67.49 59.59,67.74 R86.1 R84.1 ; R1393.1 v1(40.06,56.11) ; v1(59.88,80.02) 59.88,79.97 59.93,79.91 R561.2 ; R325.1 v1(44.47,57.98)
  BOTTOM w0.508: U36.8 59.94,74.87 59.62,74.55 v1(58.54,74.55) 58.54,76.05 57.1,77.49 57.1,79.55 56.52,80.13 56.12,80.13 55.76,80.5 R560.2 55.77,80.85 R349.1 56.05,81.65 56.85,82.46 57.78,82.46 58.19,82.05 58.19,80.86 58.73,80.32 59.58,80.32 v1(59.88,80.02) ; R13.2 46.5,82.73 C69.2 C68.2 44.28,82.74 v1(44.03,82.49) 44.03,81.67 FB13.2 ; v1(46.49,81.47) 44.57,81.47 FB13.2 ; FB13.2 43.66,80.56 R322.2
+V3.3A_PCH: length 2.7
  TOP w0.203: U1.DB34 v1(177.59,69.64) ; U1.DG28 v1(174.79,73.51) ; v1(174.79,74.34) 174.78,74.32 174.62,74.11 U1.DG26 ; U1.DF23 v1(175.44,75.17) ; U1.DC33 v1(176.43,70.93)
+V3.3AVCC: length 3
  BOTTOM w0.203: C70.1 45.4,79.1 45.36,79.06 U9.74
  BOTTOM w0.305: FB13.1 44.93,79.8 C70.1
+V3.3S: length 672.9
  TOP w0.305: R557.1 230.39,14.9 228.91,13.43 ; U33.5 232.59,45.03 C491.1 233.3,44.09 233.32,44.06 v1(233.39,44.06) ; D26.2 62.45,87.17 v1(62.88,87.6) ; CN11.255 224.72,25.38 225.17,25.82 226.36,25.82 226.7,25.48 v1(227.55,25.48) ; v1(74.8,64.05) 74.8,63.33 76.61,61.52 76.61,58.54 77.52,57.63 v1(77.52,56.99) ; 228.44,12.95 228.68,13.19 ; 228.44,12.95 228.44,13.43 ; 228.44,12.95 228.19,12.7 228.19,10.39 227.51,9.71 C139.2 224.72,9.94 CN19.255 ; 228.68,13.19 228.91,13.43 ; 228.68,13.19 228.44,13.43 ; 228.91,13.43 228.44,13.43 ; v1(227.11,14.45) 227.43,14.45 228.44,13.44 228.44,13.43 ; v1(32.64,63.68) 32.67,63.66 C432.2 ; v1(163.83,61.71) 164.12,61.43 164.62,61.43 R323.1 ; R252.1 151.54,56.78 150.63,57.69 150.63,59.36 v1(150.46,59.53) U5.5 ; v1(164.77,69.85) 164.89,69.98 R78.2 165.37,69.2 R72.2 ; R385.1 v1(35.96,63.71) ; R635.2 154.26,71.21 Q19.1 156.04,70.63 v1(156.04,70.54) ; Q27.1 154.92,74.55 R634.2 v1(153.36,73.62) 152.63,72.9 152.63,70.73 152.57,70.73 151.82,69.98 151.82,66.64 v2(152.17,66.29)
  TOP w0.406: U34.5 40.24,60.88 C340.2 40.23,59.85 v1(38.08,59.85) ; FB24.2 25.97,71.21 v1(25.93,71.24) ; v1(60.7,84.43) 60.47,84.19 60.47,81.1 Q14.1 60.58,80.98 60.58,80.64 R446.1 61.53,78.25 61.08,77.8 61.08,73.35 63.14,71.29 63.14,68.38 65.26,66.27 65.26,57.4 v1(65.98,56.68)
  TOP w0.508: 232.53,52.78 232.53,51.28 232.74,51.07 233.48,51.07 233.86,50.69 233.86,44.46 233.46,44.06 v1(233.39,44.06) ; U23.5 33.32,63.66 C432.2 33.32,62.25 32.59,61.53 R386.1 ; 233,53.72 232.99,53.72 233.13,53.86 233.13,58.96 v1(233.38,59.21) ; v1(208.62,10.88) 210.39,9.11 221.08,9.11 221.68,9.71 C141.2 C139.2 ; v1(182.01,53.96) 182.42,53.96 183.27,54.81 183.27,56.33 184.35,57.4 R649.1 ; v1(59.6,35.09) 59.6,33.72 57.78,31.9 C545.2 56.62,31.88 FB3.1
  ART03 w0.305: v1(156.04,70.54) 156.08,70.5 157.54,70.5 158.23,69.81 159.71,69.81 160.07,69.46 161.89,69.46 162.81,70.38 164.32,70.38 164.77,69.94 v1(164.77,69.85) ; v1(230.61,67.42) 230.61,68.83 232.59,70.81 232.59,91.85 231.98,92.45 231.98,94.82 v1(232.64,95.48) ; 65.81,35.09 66.16,34.73 ; 65.81,35.09 65.75,35.09 ; 65.81,35.09 66.6,35.09 ; 65.75,35.09 66.17,35.51 ; 65.75,35.09 v1(59.6,35.09)
  ART03 w1.016: v1(30.84,52.39) 30.86,52.41 v2(30.86,53.59) 30.91,53.54 30.91,61.95 v1(32.64,63.68) 32.94,63.98 35.68,63.98 v1(35.96,63.71) 36.63,64.37 v2(36.63,66.59) ; v2(51.96,13.68) 52.8,12.84 57.71,12.84 59.58,10.97 63.2,10.97 63.94,11.71 63.94,13.51 ; 63.94,13.51 64.94,14.51 ; 63.94,13.51 63.94,13.76 ; 63.94,14.95 63.94,13.76 ; 63.94,13.76 63.1,14.59
  PWR05 w0.305: v1(163.83,61.71) 163.83,60.41 163.41,59.99 157.72,59.99 156.39,61.32 153.92,61.32 152.9,62.33 v2(152.9,66.3)
  PWR05 w0.508: v1(141.3,32.55) 141.3,43.97 136.94,48.34 136.94,49.18 136.13,49.99 124.34,49.99
  ART06 w0.305: v1(153.36,73.62) 154.39,72.59 154.39,72.2 v1(156.04,70.54)
  ART06 w0.508: v1(62.88,87.6) 60.7,85.42 v1(60.7,84.43) ; v1(153.39,10.53) 152.14,10.53 150.57,12.1 150.57,17.37 149.45,18.5 147.13,18.5 142.94,22.69 142.94,32.32 142.72,32.55 v1(141.3,32.55)
  BOTTOM w0.305: 63.09,88.12 62.88,87.91 ; 63.09,88.12 63.1,88.12 ; 63.09,88.12 62.89,88.12 62.88,88.12 ; 62.88,87.91 62.88,88.12 ; 62.88,87.91 v1(62.88,87.6) ; 232.2,106.58 232.2,107.39 231.01,108.58 PR17.2 ; 232.2,106.58 232,106.38 ; 232.2,106.58 232.2,106.19 ; 232.2,106.19 232.2,105.49 232.99,104.7 232.99,101.24 232.64,100.9 v1(232.64,95.48) ; 232.2,106.19 232,106.38 ; 220.34,17.39 221.21,16.52 R292.2 222.32,15.6 222.95,14.97 223.42,14.97 223.79,14.6 223.79,13.05 224.38,12.47 226.86,12.47 227.19,12.8 227.19,14.38 v1(227.11,14.45) 227.23,14.56 227.23,15.38 227.92,16.07 227.92,19.91 226.56,21.27 226.56,26.31 227.86,27.61 C884.2 228.76,27.62 C883.2 230.12,27.34 228.26,25.48 v1(227.55,25.48) ; 220.34,17.39 219.82,16.86 204.72,16.86 204.25,16.39 203.65,16.39 203.33,16.71 R236.2 ; 220.34,17.39 220.34,19.94 ; 62.88,88.12 62.88,88.34 ; 62.88,88.34 62.88,90.55 63.82,91.48 Q2.1 ; 62.88,88.34 63.1,88.12 ; 182.01,52.21 182.01,51.48 182.06,51.43 ; 182.01,52.21 182.01,52.33 ; 182.01,52.21 181.23,51.43 ; 156.72,57.06 156.77,57.06 ; 156.72,57.06 156.14,57.06 155.95,57.25 ; 156.72,57.06 155.95,56.29 ; 156.77,57.06 156.26,57.57 ; 156.77,57.06 156.8,57.03 157.63,57.03 157.84,56.81 R192.2 ; Q42.1 66.09,24.05 v1(67.44,25.4) R828.1 ; 220.34,20.38 220.57,20.15 ; 220.34,20.38 220.34,20.39 220.34,20.97 220.34,20.97 220.34,24.32 219.87,24.78 ; 220.34,20.38 220.34,20.16 ; 220.57,20.15 220.55,20.15 ; 220.57,20.15 R241.2 ; 215.15,28.51 215.15,28.93 ; 215.15,28.51 214.7,28.51 ; 215.15,28.51 215.61,28.51 ; 215.15,28.93 215.15,30.95 215.86,31.66 217.79,31.66 218.39,32.26 R59.1 ; 215.15,28.93 215.12,28.93 214.7,28.51 ; 215.15,28.93 215.19,28.93 215.61,28.51 ; 218.91,24.78 219.39,24.78 ; 218.91,24.78 217.4,24.78 217.09,25.09 217.09,27.6 216.18,28.51 215.61,28.51 ; 218.91,24.78 219.15,25.03 ; 219.39,24.78 219.15,25.03 219.15,25.03 ; 219.39,24.78 219.87,24.78 ; 182.9,51.43 182.01,52.33 ; 182.01,52.33 v1(182.01,53.96) 182.03,53.98 R369.2 182.03,54.65 R655.2 182.04,55.42 R370.2 ; v1(74.8,64.05) 74.78,64.07 R247.2 ; 214.7,28.51 R734.2 ; 220.34,19.94 220.55,20.15 ; 220.34,19.94 220.34,20.16 ; 220.55,20.15 220.35,20.15 220.34,20.16 ; 47.75,51.01 47.43,51.01 ; 47.75,51.01 48.12,51.01 ; 47.75,51.01 47.73,50.99 47.73,50.71 ; 47.43,51.01 47.73,50.71 ; 47.43,51.01 44.01,51.01 41.71,53.31 40.84,53.31 37.67,56.48 37.67,59.45 v1(38.08,59.85) ; 219.87,24.78 220.22,25.13 220.22,25.97 220.6,26.36 R740.2 ; 47.73,50.71 47.73,50.62 ; 47.73,50.62 48.12,51.01 ; 47.73,50.62 v1(47.73,45.41) ; 232,106.38 PR68.1 ; R833.1 50.67,53.56 48.12,51.01 ; 63.1,88.12 Q1.1 ; 219.15,25.03 R735.2 ; C507.2 30.99,51.6 U35.5 ; v1(208.62,10.88) 208.96,11.22 R182.1 R183.2
  BOTTOM w0.508: v1(208.62,10.88) 208.58,10.88 207.91,10.21 205.29,10.21 204.02,11.48 193.74,11.48 193.39,11.12 187.07,11.12 186.41,10.46 184.72,10.46 184.06,11.12 153.98,11.12 v1(153.39,10.53) ; C507.2 30.99,52.23 v1(30.84,52.39) ; v1(32.64,63.68) 32.64,64.88 26.28,71.24 v1(25.93,71.24) ; CN14.24 233.12,45.8 233.39,45.52 v1(233.39,44.06) ; v1(150.46,66.1) 149.12,64.76 149.12,61.31 150.46,59.97 v1(150.46,59.53) 150.58,59.53 R47.2
  BOTTOM w1.27: 229.19,66.43 227.53,66.43 226.6,67.36 223.63,67.36 221.57,65.3 221.57,62.04 219.68,60.16 217.15,60.16 211.34,54.34 211.34,53.12 209.94,51.73 206.61,51.73 205.42,50.54 189.35,50.54 188.46,51.43 173.92,51.43 170.79,48.3 163.39,48.3 161.4,46.31 159.47,46.31 156.52,49.25 156.52,53.1 155.66,53.96 155.66,56 155.95,56.29 155.95,57.25 156.26,57.57 156.26,59.07 153.18,62.16 153.18,65.36 152.84,65.7
  BOTTOM w1.524: v2(130.68,69.28) 130.63,69.28 v2(129.92,68.57) 128.25,66.9 124.92,66.9
  vias: v1(122.27,66.04) v1(122.78,66.05) v2(61.52,17.1) v2(61.88,16.43) v2(62.39,17.1) v2(67.09,47.01) v2(67.83,47.07) v2(68.55,47.03) v2(69.29,47.02) v2(70.05,47.03) v2(98.44,76.35) v2(98.72,75.48) v2(99.28,76.12) v2(122.51,66.64) v2(123.01,67.2) v2(123.28,66.47) v2(123.47,67.78) v2(123.77,67.01) v2(124.13,68.33) v2(124.31,67.55)
+V3.3S_AUDIO: length 9.3
  TOP w0.305: v1(36.73,78.77) 36.17,78.77 R408.1 ; R399.1 36.06,71.62
  BOTTOM w0.406: R410.1 36.58,75.97 37.42,75.97 R409.1 ; R410.1 36.46,73.94 v1(37.3,73.1) ; R410.1 36.04,76.08 35.71,76.42 35.71,77.75 v1(36.73,78.77)
+V3.3S_DMIC: length 6.9
  BOTTOM w0.762: FB16.1 132.21,65.14 132.97,64.38 132.97,60.04 133.24,59.77 CN2.10
+V3.3S_DVDD: length 33.1
  TOP w0.203: U25.1 33.49,77.75 34.74,76.51 C483.2
  TOP w0.305: C483.2 34.96,76.5 C482.1 34.96,74.62 35.12,74.45 FB31.1 FB30.1 34.77,72.71 v1(34.77,72.29) ; v1(37.73,86.08) 37.64,85.99 R401.1 37.02,84.74 R400.1 ; R396.1 v1(40.4,84.35)
  TOP w0.406: R507.1 34.88,88.22 35.12,88.46 v1(35.12,88.53)
  ART03 w0.305: v1(37.73,86.08) 36.82,86.08 36.82,86.07
  ART03 w0.406: 37.13,84.35 37.13,84.31 36.82,84 ; 37.13,84.35 36.82,84.66 ; 37.13,84.35 36.88,84.35 36.82,84.29 ; 37.13,84.35 v1(40.4,84.35) ; 36.82,84.66 36.82,84.29 ; 36.82,84.66 36.82,86.84 v1(35.12,88.53) ; 36.82,84.29 36.82,84 ; v1(34.77,72.29) 34.77,75.51 35.36,76.1 35.36,79.98 36.82,81.44 36.82,84
+V3.3S_MSATA: length 22.5
  TOP w0.305: 96.94,64.16 U40.5 ; 96.94,64.16 96.94,64.31 ; 96.94,64.16 96.77,64.32 ; 96.94,64.16 96.95,64.16 97.13,64.34
  TOP w0.406: 109.43,58.9 109.08,58.9 ; 109.43,58.9 110.13,58.9 R338.2 ; 109.43,58.9 109.1,59.23 109.08,59.23 ; 109.08,58.9 108.75,58.9 ; 109.08,58.9 109.08,59.23 ; 97.34,56.79 97.34,57.67 98.15,58.47 100.99,58.47 102.19,59.67 105.92,59.67 106.69,58.9 108.75,58.9 ; 108.75,58.9 109.08,59.23 ; 109.08,59.23 109.08,61.27 109.47,61.66 R210.2
  vias: v2(96.75,56) v2(97.53,56.02) v2(97.58,64.53) v2(98.36,64.53)
+V3P3_BIOS_SPI: length 15.2
  TOP w0.203: R722.1 143.69,64.89 U49.8
  TOP w0.305: R723.1 130.36,62.44 v1(130.54,62.62)
  TOP w0.406: 136.55,66.2 136.69,66.2 ; 136.55,66.2 131.33,66.2 R721.1 130.93,66.23 v1(130.81,66.11) ; 136.55,66.2 136.96,66.61 ; 136.69,66.2 137.07,65.82 ; 136.69,66.2 136.99,66.2
  BOTTOM w0.406: v1(130.54,62.62) 131.81,63.9 131.81,64.51 130.79,65.53 130.79,66.09 v1(130.81,66.11)
+V3P3_DSW: length 315
  TOP w0.305: 137.95,75.36 137.94,75.36 137.63,75.67 ; 137.95,75.36 137.98,75.36 138.26,75.65 ; 137.95,75.36 137.95,74.96 137.67,74.68 134.58,74.68 134.24,75.02 125.05,75.02 124.69,75.38 R38.2 124.29,76.21 R40.2 ; v1(121.14,76.33) R37.1 ; v1(164.22,56.45) 164.28,56.51 164.3,56.51 R97.1 164.66,56.88 R31.1 ; v1(163.71,58.67) 163.92,58.87 R69.1 164.64,58.9 R22.1 ; R34.1 93.7,90.22 v1(93.85,90.07)
  TOP w0.508: v1(77.91,68.95) 77.91,69.04 77.06,69.88 77.06,71.74 74.39,74.41 70.38,74.41 69.88,74.91 66.84,74.91 64.39,77.36 64.39,84.21 v1(64.92,84.75) ; 139.86,76.15 v2(139.17,76.15) ; 139.86,76.15 140.19,76.15 ; 139.86,76.15 139.53,75.82 ; 140.19,76.15 141.49,76.15 v1(141.69,75.95) ; 140.19,76.15 139.68,76.66
  ART03 w0.305: v1(164.22,56.45) 164.22,56.47 163.71,56.97 v1(163.71,58.67)
  ART03 w0.508: v1(155.27,75.44) 154.8,75.91 147.85,75.91 147.31,76.46 145.86,76.46 145.21,75.8 141.84,75.8 v1(141.69,75.95)
  ART06 w0.305: v1(163.71,58.67) 161.48,58.67 160.9,58.08 158.28,58.08 157.84,58.52 155.95,58.52 155.21,59.26 153.88,59.26 153.52,58.9 149.68,58.9 ; v1(93.85,90.07) 94.26,89.67 114.33,89.67 117.94,86.05 123.38,86.05 127.39,82.05 v1(128.56,82.05) ; 149.68,58.9 149.2,58.43 ; 149.68,58.9 149.25,58.9 149.2,58.86
  ART06 w0.508: v1(127.24,77.71) 126.85,77.32 121.57,77.32 120.38,78.51 120.12,78.51 117.3,81.33 102.79,81.33 102.42,81.71 90.85,81.71 88.66,79.51 88.66,74.41 82.86,68.61 78.25,68.61 v1(77.91,68.95)
  ART06 w0.635: v2(139.17,76.15) 139.17,68.96 141.36,66.77 141.74,66.77 144.05,64.45 145.76,64.45 147.83,62.39 147.83,60.71 149.2,59.33 149.2,58.43 v1(149.14,58.36)
  BOTTOM w0.203: 158.54,71.77 158.22,72.09 ; 158.54,71.77 158.54,71.77 ; 158.54,71.77 158.54,72.09 ; 158.54,71.77 158.54,71.4 159.09,70.85 160.01,70.85 160.22,71.05 160.6,71.05 163.32,68.33 163.84,68.33 165.22,66.96 168.49,66.96 168.84,66.61 168.84,63.97 169.81,63.01 175.39,63.01 R28.1 ; 158.54,71.77 158.87,72.09
  BOTTOM w0.305: R792.1 119.08,79.81 120.29,78.61 120.89,78.61 121.15,78.88
  BOTTOM w0.508: v1(149.14,58.36) 149.88,57.62 149.88,55.67 150.73,54.82 150.73,54.2 151.32,53.61 151.44,53.61 151.78,53.27 151.78,52.69 150.89,51.8 150.89,46.27 153.23,43.94 156.24,43.94 159.36,40.82 173.26,40.82 D1.P ; v1(64.92,84.75) 64.23,85.44 61.53,85.44 61.2,85.77 57.49,85.77 56.55,86.7 56.55,89.1 55.94,89.71 49.71,89.71 47.5,87.51 47.5,84.51 R13.1 ; R51.1 168.03,70.6 164.75,70.6 164.53,70.38 162.74,70.38 160.99,72.13 158.91,72.13 158.87,72.09 157.77,72.09 155.27,74.6 v1(155.27,75.44)
  vias: v2(136.67,78.49) v2(136.67,77.72) v2(136.67,76.96) v2(136.67,76.2) v2(139.17,78.44) v2(139.17,77.67) v2(139.17,76.91)
+V3P3_DSW_EN: length 7.8
  TOP w0.203: U20.11 124.04,79.14 v1(124.43,78.75) 125.07,78.11 C331.2
  ART06 w0.305: v1(124.43,78.75) 123.61,77.93 121.78,77.93 120.62,79.09 v1(120.62,79.21)
  BOTTOM w0.305: v1(120.62,79.21) 120.1,79.73 R899.2
+V3P3A: length 743.7
  TOP w0.305: R160.2 162.78,70.41 R30.1 161.99,71.2 R8.1 161.88,71.08 R16.1 160.71,71.08 160.66,71.14 160.66,71.26 160.61,71.31 v1(160.61,71.51) 160.32,71.79 160.32,72.02 ; 160.17,73.79 160.52,73.79 ; 160.17,73.79 160.32,73.64 160.32,73.59 ; 160.17,73.79 158.77,73.79 158.76,73.8 ; 160.52,73.79 161.61,73.79 161.99,74.17 R648.1 161.98,74.57 R647.1 ; 160.52,73.79 160.32,73.59 ; v1(167.38,55.95) 169.54,53.78 171.15,53.78 171.39,54.03 R866.2 ; 160.32,72.02 R906.2 ; 160.32,72.02 v1(160.32,73.35) 160.32,73.59 ; R636.1 163.81,74.92 164.28,74.45 164.28,74.09 164.53,73.84 R654.2 ; R636.1 163.77,75.09 R92.1 164.13,76.08 R653.2 ; R636.1 162.84,74.92 R637.1 162.7,74.92 162.28,75.34 R647.1 ; R373.1 v1(219.74,90.05) ; R647.1 161.86,75.47 R644.2 161.95,76.23 161.95,77.44 162.3,77.8 163.38,77.8 163.67,78.08 R58.2 164.36,77.77 R904.2 ; R234.1 147.93,81.65 147.13,82.46 v1(147.13,82.52) ; R93.1 164.24,62.19 163.89,62.54 163.89,64.25 164.78,65.14 R311.1 R312.1 162.68,65.97 R347.1 R346.1 161.81,67.66 161.28,68.2 v1(161.28,68.23) 160.98,67.94 R876.2 ; 157.21,76.61 156.95,76.35 ; 157.21,76.61 156.96,76.61 ; 157.21,76.61 R179.2 ; 156.95,76.35 156.95,74.77 157.22,74.5 158.26,74.5 158.76,74 158.76,73.8 ; 156.95,76.35 156.95,76.39 ; 156.96,76.61 156.95,76.6 156.95,76.39 ; 156.96,76.61 156.73,76.61 ; v1(159.28,70.31) 159.01,70.58 R632.1 R12.1 ; v1(163.34,82.8) 163.7,82.44 R156.1 ; R10.2 156.73,78.33 R9.2 156.73,79.83 R873.2 155.57,79.91 R49.2 155.44,80.94 v1(155.49,80.98) ; 156.73,76.61 156.13,76.61 R57.2 ; 156.73,76.61 156.95,76.39 ; R633.1 158.76,73.8 ; R609.1 164.93,79.64 164.93,79.64 v1(164.93,79.65) ; R412.1 v1(151.5,46.67) ; R116.1 R115.1 51.25,67.52 50.33,66.6 50.33,65.71 51.25,64.8 51.25,62.46 52.68,61.03 v1(52.71,61.03)
  TOP w0.406: v1(157,55.33) 157.79,55.33 158.67,56.21 158.67,57.82 158.12,58.37 158.12,59.63 152.51,65.24 146.12,65.24 142.15,69.22 134.3,69.22 133.9,68.82 R476.1
  TOP w0.508: v1(120.86,99.06) 120.86,108.94 125.06,113.13 125.06,114.53 LED2.1 126.19,114.82 128.31,114.82 129.51,113.61 129.51,112.41 130,111.93 132.57,111.93 134,110.5 137.53,110.5 138.86,111.82 143,111.82 143.61,111.2 143.61,108.5 143.25,108.13 143.25,105.27 145.23,103.29 148.45,103.29 149.24,102.5 R205.1 R194.1 ; FB9.1 57.04,30.61 v1(57.56,31.12)
  TOP w0.762: R476.1 132.89,67.27 127.49,67.27 126.56,68.2 126.56,69.24 124.99,70.81 v2(124.93,70.81)
  ART03 w0.305: 147.2,81.15 141.05,81.15 140.5,80.6 135.47,80.6 133.93,79.06 133.93,74.23 133.15,73.45 131.56,73.45 130.33,74.69 128.58,74.69 v2(125.81,71.92) ; 147.2,81.15 147.51,81.15 ; 147.2,81.15 147.57,81.52 ; 147.92,81.15 155.32,81.15 v1(155.49,80.98) ; 147.92,81.15 147.57,81.5 147.57,81.52 ; 147.92,81.15 147.51,81.15 ; 147.57,81.52 147.57,81.22 147.51,81.15 ; 147.57,81.52 147.57,82.07 v1(147.13,82.52) ; 147.57,81.52 147.57,81.52 ; v1(52.71,61.03) 53.83,61.03 54.48,60.38 72.11,60.38 72.84,59.65 77.64,59.65 v1(77.8,59.49) ; 59.35,32.91 59.77,33.33 59.79,33.33 ; 59.79,33.33 59.47,33.65 ; 59.79,33.33 62.96,33.33 64.61,31.68 v1(64.61,28.19) ; v1(163.34,82.8) 163.61,82.53 164.31,82.53 165.21,83.43 165.21,85.36 166.1,86.25 167.21,86.25 v1(167.35,86.38)
  PWR05 w1.016: v2(141.95,31.29) 143.85,33.19 143.85,43.25 138.22,48.88 138.22,52.11 136.05,54.27 128.9,54.27 127.49,55.69 127.49,61.4 128.09,62 128.09,64.7
  ART06 w0.203: v1(161.51,97.42) 161.48,97.42 160.31,96.25 160.31,90.7 161.75,89.26 164.47,89.26 v1(167.35,86.38) ; v1(156.26,83.13) 156.05,82.92 156.05,81.32 155.72,80.98 v1(155.49,80.98) ; v1(205.75,8.34) 205.91,8.34 206.31,7.93 231.78,7.93 234.12,10.27 234.12,15.03 233.59,15.56 233.59,22.14 234.17,22.72 234.17,29.91 233.24,30.84 233.24,38.73 234,39.49 234,42.69 232.69,44 232.69,60.92 232.98,61.21 232.98,77.79 232.98,77.8 232.98,78.25 232.98,78.26 232.98,92.24 233.6,92.86 233.6,94.28 233.39,94.48 225.6,94.48 224.45,93.34 224.45,92.48 222.1,90.13 220.18,90.13 220.11,90.05 v1(219.74,90.05)
  ART06 w0.305: v1(157,55.33) 153.59,55.33 v1(153.43,55.49) ; v1(57.56,31.12) 56.91,31.78 53.79,31.78 49.21,27.19 45.7,27.19 41.85,23.34 36.54,23.34 33.94,20.74 33.94,18.52 v1(33.91,18.48) ; v1(159.28,70.31) 159.28,70.56 159.57,70.84 159.94,70.84 v1(160.61,71.51)
  ART06 w0.508: v1(120.86,99.06) 118.55,96.75 v1(118.55,94.08)
  BOTTOM w0.203: R934.2 33.96,16.72 R933.2 33.96,18.43 v1(33.91,18.48) ; R139.1 161.65,97.57 v1(161.51,97.42) ; v1(205.75,8.34) 205.75,8.5 205.7,8.55 ; R862.1 144.34,90.46 R860.1 144.34,89.49 145.81,88.02 145.81,83.47 146.76,82.52 v1(147.13,82.52)
  BOTTOM w0.254: v2(109.94,60.98) 110.2,60.72 110.2,59.9
  BOTTOM w0.305: 168.45,55.85 171.04,55.85 171.48,56.29 174.37,56.29 175.36,57.28 175.36,60.67 175.88,61.19 R831.2 176.37,62.4 R3.1 177.73,62.81 R154.1 178.27,63.35 R927.1 178.73,63.35 R928.1 179.55,63.34 R610.1 ; 168.45,55.85 168.19,55.85 ; 168.45,55.85 168.21,56.09 ; v1(160.61,71.51) 160.68,71.43 160.8,71.43 163.44,68.8 163.89,68.8 165.32,67.37 169.22,67.37 169.45,67.13 172.4,67.13 172.89,66.64 R907.2 172.95,66.5 R175.2 174.66,65.97 R176.1 ; v1(159.28,70.31) 159.28,70.18 158.85,69.75 158.85,68.47 159.82,67.5 160.99,67.5 ; v1(153.43,55.49) 152.45,54.51 152.45,52.61 151.5,51.66 v1(151.5,46.67) ; R650.2 178.09,52.37 173.33,52.37 170.15,49.19 162.57,49.19 162.07,48.69 159.46,48.69 157.98,50.17 157.98,51.51 ; 168.21,56.09 168.21,56.08 ; 168.21,56.09 R107.2 ; 168.21,56.08 167.98,55.85 ; 168.21,56.08 168.21,55.87 168.19,55.85 ; R70.2 110.2,56.32 110.2,59.9 ; 167.98,55.85 167.47,55.85 v1(167.38,55.95) 167.14,56.19 166.66,56.19 164.88,57.97 164.88,59.31 164.46,59.73 164.46,61.99 163.53,62.92 163.53,64.67 163.39,64.8 163.39,65.33 161.22,67.5 ; 167.98,55.85 168.19,55.85 ; R316.2 164.02,90.09 164.02,84.02 163.23,83.23 163.23,82.91 v1(163.34,82.8) 163.34,82.76 161.88,81.29 156.35,81.29 156.05,80.98 v1(155.49,80.98) ; U57.5 64.32,27.9 v1(64.61,28.19) ; R905.2 165.33,79.96 165.02,79.65 v1(164.93,79.65) 164.81,79.65 163.88,80.58 163.88,81.53 165.65,83.3 166.1,83.3 166.76,83.96 166.76,85.8 v1(167.35,86.38) 166.27,87.46 166.27,89.73 166.38,89.84 R310.2 ; 160.99,67.5 161.22,67.73 ; 160.99,67.5 161.22,67.5 ; 161.22,67.73 161.22,67.5 ; 161.22,67.73 161.22,68.17 v1(161.28,68.23) ; v1(156.26,83.13) 155.95,83.44 U56.5 ; U54.5 158.94,53.17 158.68,52.9
  BOTTOM w0.406: v1(157,55.33) 157,54.41 157.59,53.82 157.76,53.82 158.68,52.9 158.01,52.23 158.01,51.53 157.98,51.51
  BOTTOM w0.762: FB16.2 132.21,67.5 133.71,69 133.71,74.63 133.04,75.3 131.86,75.3 131.3,74.74 126.49,74.74 126.1,74.36
  BOTTOM w1.016: R195.2 204.71,8.55 203.19,10.07 195.43,10.07 193.91,8.55 152.54,8.55 151,10.09 151,17.57 150.87,17.7 150.87,18.05 150.04,18.89 149.42,18.89 149.34,18.97 147.29,18.97 141.95,24.31 v2(141.95,31.29)
  vias: v1(77.77,58.98) v1(125.36,72.34) v1(125.71,72.74) v1(126.12,72.44) v2(52.69,47.35) v2(53.47,47.35) v2(61.85,20.14) v2(61.88,20.87) v2(78.42,59.44) v2(117.69,90.6) v2(117.73,89.82) v2(123.96,70.79) v2(124.42,71.33) v2(124.99,71.82) v2(125.49,71.3) v2(162.13,73.68)
+V3P3A_RTC: length 69.3
  ART03 w0.508: v1(166.56,57.87) 166.56,56.4 164.61,54.45 164.61,53.14 164.23,52.75 162.04,52.75 157.96,48.67 157.96,45.82 v1(157.18,45.04)
  ART06 w0.508: v1(165.36,68.42) 165.2,68.26 163.42,68.26 163.01,68.68 162.54,68.68 162.15,68.29 162.14,68.29 v1(162.14,68.2)
  BOTTOM w0.406: R27.2 165.96,57.67 165.41,58.22 165.41,59.58 164.96,60.03 164.96,62.38 164.12,63.22 164.12,64.3 164.6,64.78 R25.2 166.39,65.27 R71.2
  BOTTOM w0.508: D1.N 178.34,45.03 D3.N 177.36,46.01 176.36,46.01 172.63,42.28 159.22,42.28 158.97,42.53 157.18,44.32 v1(157.18,45.04) ; v1(162.14,68.2) 162.16,68.18 162.16,67.33 162.78,66.71 162.78,66.71 163.11,66.38 163.12,66.38 163.38,66.11 164.48,66.11 164.69,66.32 165.92,66.32 166.39,65.85 R71.2 ; v1(166.56,57.87) 166.29,57.87 R27.2 ; v1(165.36,68.42) 165.7,68.42 165.72,68.44 C136.2 165.89,68.43 C308.2 167.1,68.02 167.96,68.02 168.34,68.39 R50.1
+V5_AVDD: length 0.8
  TOP w0.203: U25.26 27.23,82.05
  TOP w0.254: 27.23,82.05 26.99,82.28
+V5_PVDD: length 11.7
  TOP w0.203: U25.41 29.99,76.71 29.67,76.4 29.67,76.22 ; 32.6,76.34 32.59,76.34 31.99,76.95 U25.46
  TOP w0.406: 32.6,76.34 32.75,76.2 32.75,75.23 C480.2 ; C476.2 29.67,75.14 29.67,76.22
  TOP w0.508: C476.2 29.88,74.94 29.88,74.14 C477.2 32.15,73.49 C481.2 ; FB26.1 C481.2 ; C481.2 32.17,74.11 32.65,74.59 C480.2
+V5A: length 698.5
  TOP w0.203: v1(125.69,112.85) 125.69,113.63 126.28,114.22 128.14,114.22 129.02,113.34 129.02,112.11 129.7,111.44 132.21,111.44 134.38,109.27 134.38,108.86 134.85,108.39 136.2,108.39 139.05,111.24 142.75,111.24 143.09,110.9 143.09,108.69 142.71,108.31 142.71,105.13 145.06,102.78 147.28,102.78 147.63,102.43 147.63,101.65 148.19,101.09 R206.2 ; F3.1 40.33,110.07 40.33,109.04 39.82,108.53 39.82,107.81 40.37,107.27 R478.1 ; R918.1 17.46,113.04 17.66,112.84 17.66,111.46 16.62,110.42 U11.5 ; R490.1 56.65,110.32 56.13,110.84 56.13,112.02 F6.1 ; v1(91.18,89.97) 91.18,89.91 C25.1 91.82,89.07 91.55,88.8 U7.10
  TOP w0.254: U55.4 C399.2
  TOP w0.305: v1(113.9,56.83) 114.04,56.83 114.27,57.06 114.27,58.17 114.71,58.61 114.71,58.96 115.57,59.82 115.57,61.31 v1(115.47,61.4) ; v1(81.91,88.51) C27.1 82.69,88.74 D5.1 ; U21.4 156.48,88 156.51,87.97 C295.2 156.51,87.56 v1(157.06,87.01) ; v1(157.94,90.66) 157.94,90.68 157.86,90.76 157.86,91.48 C114.2 157.81,92.2 U15.4 ; 143.8,73.38 143.4,73.79 ; 143.8,73.38 143.82,73.38 ; 143.8,73.38 142.41,73.38 ; C399.2 143.82,73.38 ; 143.82,73.38 143.34,72.9 ; 83.96,73.08 83.59,72.71 83.59,72.7 83.2,72.3 83.2,71.64 82.99,71.44 R795.2 ; R793.2 82.74,75.13
  TOP w0.508: FB38.1 v1(23.29,89.64) ; v1(84.21,56.66) 84.21,55.26 82.06,53.11 78.13,53.11 77.01,54.23 54.32,54.23 48.8,48.7 48.8,39.65 50.84,37.61 58.54,37.61 60.64,35.51 60.64,26.89 57.14,23.4 57.14,20.62 54.93,18.41 54.93,16.56 53.7,15.34 53.7,10.34 54.88,9.16 v1(57.73,9.16)
  ART03 w0.305: v1(117.39,61.4) v1(115.47,61.4)
  ART03 w0.508: v2(90.49,78.7) 90.49,89.97 v1(91.18,89.97) ; v1(216.69,98.72) 219.94,98.72 221.03,99.81 225.43,99.81 225.93,99.31 229.64,99.31 230.4,100.06 230.4,102.74 v2(232.03,104.37) ; v1(11.84,108.85) 16.78,108.85 21.21,104.41 21.21,92.06 23.29,89.98 v1(23.29,89.64)
  ART03 w1.016: 130,72.65 133.44,72.65 134.99,74.2 134.99,78.91 135.89,79.81 143.6,79.81 144.07,80.28 148.4,80.28 149.25,79.43 v1(150.23,79.43)
  ART06 w0.305: v2(170.27,101.54) 170.27,101.38 169.49,100.6 166.74,100.6 166.21,101.13 v1(166.21,101.14)
  ART06 w0.406: v1(115.47,61.4) 114.67,62.2 114.15,62.2 112.64,63.72 106.05,63.72 105.92,63.85 92.24,63.85 v1(89.39,60.99) ; v1(157.94,90.66) 157.94,90.36 158.3,89.99 158.3,88.82 157.06,87.57 v1(157.06,87.01)
  ART06 w0.508: v2(232.03,104.37) 231.28,104.37 228.28,107.36 226.64,107.36 226.09,107.91 220.39,107.91 218.87,106.39 v1(217.72,106.39) ; v1(86.65,112.22) 86.65,112.44 86.83,112.63 89.34,112.63 89.74,112.22 112.37,112.22 113,112.85 v1(125.69,112.85) 126.61,111.94 133.96,111.94 134.23,111.66 138.47,111.66 138.91,112.1 151.53,112.1 158.2,105.43 158.2,103.92 158.95,103.17 v1(158.95,103.02)
  BOTTOM w0.203: 113.77,56.12 113.79,56.1 U2.12 ; U27.5 54.44,100.3 52.56,100.3 52.29,100.57 R449.1
  BOTTOM w0.254: C520.2 57.96,9.92 U39.4 ; U16.4 162.23,53.01 C128.2
  BOTTOM w0.305: C411.1 212.73,10.49 212.58,10.64 210.45,10.64 209.36,9.54 205.02,9.54 203.65,10.91 194.39,10.91 193.26,9.78 184.12,9.78 183.39,10.51 178,10.51 177.26,9.78 152.76,9.78 152.07,10.48 152.07,18.5 150.64,19.93 147.99,19.93 143.31,24.61 143.31,31.99 141.01,34.29 141.01,39.46 arc(140.33,42.89) 138.38,45.8 136.73,47.45 136.73,49.75 135.55,50.94 128.99,50.94 128.6,51.33 128.6,54.39 129.32,55.11 129.32,57.76 124,63.09 122.31,63.09 120.62,61.4 v1(117.39,61.4) ; v1(113.9,56.83) 113.9,56.88 113.88,56.91 C195.2 113.4,56.49 113.77,56.12 ; v1(166.21,101.14) 166.21,100.55 R309.1 ; v1(115.47,61.4) 114.04,61.4 111.63,58.99 PR92.2 ; C520.2 57.87,9.31 v1(57.73,9.16) ; C128.2 163.89,54.92 163.89,55.6 161.77,57.73 161.23,57.73 160.39,58.57 160.39,59.12 160.17,59.35 158.67,59.35 155.73,62.29 155.73,65.18 156.31,65.75 156.31,66.32 156.24,66.39 156.24,68.73 154.51,70.46 154.51,70.99 153.51,71.98 150.81,71.98 150.8,72 150.78,72 149.77,73.01 149.77,73.03 149.41,73.38 149.41,78.61 v1(150.23,79.43) ; PR3.2 217.98,106.13 v1(217.72,106.39)
  BOTTOM w0.406: 89.62,75.26 90.02,74.86 90.05,74.86 90.4,75.21 ; 90.05,75.88 90.12,75.81 90.12,75.31 90.05,75.24 ; PR78.1 231.64,103.37 231.69,103.37 232.03,103.71 v2(232.03,104.37)
  BOTTOM w0.508: v1(216.69,98.72) 217,98.41 PR98.1 ; v2(170.27,101.54) 170.14,101.54 170.14,102.49 168.5,104.13 166.55,104.13 165.8,103.38 164.56,103.38 163.2,104.74 160.18,104.74 159.01,103.58 159.01,103.08 v1(158.95,103.02) ; 84.69,88.51 v1(81.91,88.51) ; 84.69,88.51 85.15,88.98 ; 84.69,88.51 84.76,88.51 ; 85.14,88.13 84.76,88.51 ; 84.76,88.51 85.47,88.51 ; 90.05,75.24 90.05,67.03 89.39,66.37 v1(89.39,60.99) 88.55,60.99 v1(84.21,56.66) ; v1(217.72,106.39) 217.31,106.81 216.06,106.81 215.43,106.18 PC42.1 215.41,105.73 214.43,105.73 213.64,104.93 213.64,102.53 212.01,100.9 210.02,100.9 209.23,100.12 202.02,100.12 200.14,102 ; v1(157.06,87.01) 155.27,87.01 152.08,83.82 152.08,80.73 150.77,79.43 v1(150.23,79.43) ; 170.73,102.01 174.02,102.01 175.11,100.92 182.49,100.92 182.65,100.76 193.39,100.76 194.58,101.94 200.08,101.94 200.14,102 ; PR12.2 202.04,105.64 200.69,105.64 200.14,105.08 200.14,102
  BOTTOM w0.61: U52.6 C411.1
  vias: v1(44.21,110.04) v1(44.75,110.04) v1(45.31,110.04) v1(59.29,111.86) v1(59.84,111.86) v1(60.36,111.86) v2(11.84,109.67) v2(89.64,78.65) v2(89.64,77.81) v2(89.64,76.98) v2(89.59,76.16) v2(90.45,76.2) v2(90.49,77.86) v2(90.49,77.02) v2(129.03,73.62) v2(128.98,72.93)
+V5S: length 364.7
  TOP w0.203: v1(59.86,70.93) 59.76,70.93 59.34,71.36 59.34,73.12 60.4,74.18 60.4,77.5 59.42,78.48 53.25,78.48 51.92,79.81 51.92,80.85 v1(52.33,81.26)
  TOP w0.305: v1(232.52,23.2) 232.36,23.04 R558.1 ; R624.2 148.28,60.8 148.5,61.01 v1(148.5,61.06)
  TOP w0.406: v1(60.95,94.87) 60.95,101.65 63.19,103.89 C231.2 U38.3
  TOP w0.508: R393.2 31.79,89.32 v1(32.2,89.73) ; FB27.1 25.62,89.23 v1(25.84,89.01)
  TOP w1.016: 91.37,51.57 100.06,51.57 100.93,50.69 109.54,50.69 110.01,50.22 116.29,50.22 v2(117.06,50.99) ; 91.37,51.57 91.37,51.49 90.64,50.76 ; 91.37,51.57 90.53,52.41 ; 91.37,51.57 90.75,51.57 ; v1(232.52,23.2) 233.24,23.92 FB15.1
  ART03 w0.305: v1(148.5,61.06) 148.03,61.53 145.98,61.53 145.67,61.21 136.81,61.21 136.49,60.9 130.79,60.9 129.03,59.13 127.44,59.13 125.38,57.07 123.75,57.07 122.84,56.15 109.1,56.15 108.97,56.03 105.65,56.03 104.88,56.8 98.43,56.8 98.17,57.06 93.87,57.06 93.46,56.65 v1(90.48,56.65)
  ART03 w0.508: v1(37.48,87.88) 37.67,88.07 v1(41.63,88.07)
  ART06 w0.305: v1(52.33,81.26) 51.95,81.64 49.6,81.64 49.07,82.17 49.07,83.03 49.86,83.82 ; v2(88.95,70.59) 89.96,71.6 92.96,71.6 96.32,68.25 108.62,68.25 v1(109.01,67.86)
  ART06 w0.508: 30.78,89.26 30.78,88.44 31.34,87.88 v1(37.48,87.88) ; v1(60.95,94.87) 60.95,90.21 v1(59,88.26) 54.56,83.82 49.86,83.82 48.74,84.93 48.02,84.93 47.19,84.11 45.22,84.11 41.63,87.69 v1(41.63,88.07)
  ART06 w0.762: v1(150.94,36.12) 149.3,36.12
  ART06 w1.016: v2(231.97,16.74) 231.97,16.69 231.98,16.67 231.98,15.46 229.55,13.03 229.55,10.67 228.55,9.67 214.21,9.67 213.06,10.82 210.08,10.82 209.23,9.98 205.25,9.98 204.52,10.7 189.29,10.7 188.68,10.09 184.62,10.09 183.85,10.86 156.47,10.86 152.86,14.47 152.86,17.52 150.09,20.29 148.57,20.29 146.08,22.78 146.08,32.9 149.3,36.12 149.3,36.36 136.63,49.03
  BOTTOM w0.305: v1(59.86,70.93) 59.83,70.9 R165.1 ; v1(59.58,66.04) 59.44,66.17 R1400.1 ; v1(52.33,81.26) 52.29,81.22 R140.1 R138.1 51.05,82.97 50.74,83.28 R258.1 ; v1(59,88.26) 58.69,87.95 D7.P ; R752.1 108.35,60.61 108.35,67.2 v1(109.01,67.86) ; D4.2 63.9,93.04 62.07,94.87 v1(60.95,94.87) 60.95,96.49 59.93,97.51 D16.2
  BOTTOM w0.508: 233.63,31.48 233.63,35.85 233.27,36.21 231.95,36.21 CN14.8
  vias: v2(24.56,54.95) v2(25.33,54.95) v2(26.09,54.95) v2(26.39,55.73) v2(32.8,67.78) v2(61.36,14.47) v2(61.62,15.18) v2(61.78,13.79) v2(72.87,47) v2(73.64,47) v2(74.55,47.07) v2(75.28,47) v2(87.33,70.55) v2(87.31,69.76) v2(88.12,70.59) v2(88.11,69.75) v2(88.15,68.96) v2(88.13,51.63) v2(88.94,69.75) v2(88.95,68.98)
+V5S_CAM:
  vias: v2(135.65,48.66)
+V5S_HDMI: length 17.6
  TOP w0.305: CN3.18 58.24,94.81
  TOP w0.406: U38.2 C230.2 60.69,104.09 60.15,103.54 60.15,95.7 59.26,94.81 58.24,94.81
+V15A: length 69.3
  TOP w0.305: v1(87.86,89.34) 87.8,89.39 83.42,89.39 83.19,89.62 C29.1 83.32,90.21 D6.2
  ART03 w0.305: v1(116.15,78.52) 116.04,78.52 115.54,79.02 115.54,86.37 v1(115.46,86.45) ; v1(119.95,77.5) 120.05,77.39 120.05,75.8 v1(119.73,75.47)
  ART06 w0.305: v1(115.46,86.45) 114.44,87.47 94.77,87.47 93.44,88.79 88.41,88.79 v1(87.86,89.34)
  BOTTOM w0.203: R815.1 R791.1 119.73,75.38 v1(119.73,75.47)
  BOTTOM w0.305: R203.1 115.8,63.19 114.54,64.45 114.54,66.28 R196.1 115.34,68.78 115.34,76.95 115.89,77.5 ; v1(116.15,78.52) 115.89,78.26 115.89,77.5 ; 115.89,77.5 v1(119.95,77.5)
+VCC1.05_OUT_PCH: length 1.3
  TOP w0.203: U1.DG31 v1(174.79,71.85)
  BOTTOM w0.504: R212.1 174.69,71.75 v1(174.79,71.85)
+VCC1.05_OUT_PCH_R: length 2.3
  TOP w0.203: v1(175.5,72.67) 175.41,72.57 U1.DF29 ; U1.DG29 v1(174.79,72.64) ; U1.DF31 v1(175.44,71.85)
  BOTTOM w0.508: v1(174.79,72.64) 174.74,72.7 R212.2
+VCC1.05_OUT_SFR: length 0.8
  TOP w0.508: v1(186.78,88.04) 186.51,87.77 186.51,87.4
+VCCA_CLKLDO_1P8: length 5.3
  TOP w0.201: v1(167.18,79.41) 167.6,78.99 U1.DW15
  BOTTOM w0.305: v1(167.18,79.41) 167.18,79.96 167.73,80.51 167.73,81.13 C200.1 167.87,81.27 168.8,81.27 R442.1
+VCCDPHY_1P24: length 1.6
  TOP w0.203: U1.DW32 168.41,71.13 v1(168.11,71.43)
  BOTTOM w0.305: v1(168.11,71.43) 167.95,71.59 C192.2
+VCCDSW_1P05: length 0.6
  TOP w0.305: v1(176.69,69.72) 176.44,69.96 U1.DD34
+VCCFPGM: length 4.3
  TOP w0.203: U1.U35 U1.T34 v1(209.77,70.29) ; U1.W35 208.03,69.4 U1.V34 v1(208.93,70.29) ; v1(210.28,69.84) U1.R35 ; U1.AB34 v1(206.97,70.29)
  TOP w0.305: U1.AA35 207.11,69.4 U1.Y34
  vias: v1(208.04,70.32)
+VCCHDA: length 11.2
  TOP w0.305: 150.97,53.8 150.97,53.7 151.19,53.48 ; 150.97,53.8 150.97,54.6 151.32,54.95 v1(151.32,54.98) 151.35,54.95 151.78,54.95 R260.2 ; 150.97,53.8 150.66,53.49 ; 151.19,53.48 150.66,53.48 150.66,53.49 ; 151.19,53.48 R627.1 ; R628.1 148.45,52.98 148.97,53.49 150.66,53.49
  BOTTOM w0.305: v1(151.32,54.98) 152.07,55.73 R47.1 R46.1
+VCCIN: length 263.3
  TOP w0.125: U1.CJ11 184.03,80.96 ; U1.CJ11 183.53,80.96 ; U1.CJ11 184.03,81.46 ; U1.CJ11 183.53,81.46 ; U1.K29 212.09,72.24 ; U1.K29 212.59,72.73 ; U1.K29 212.59,72.24 ; U1.K29 212.09,72.73 ; 189.94,82.39 U1.BT9 ; U1.BT9 190.43,81.89 ; U1.BT9 190.43,82.39 ; U1.BT9 189.94,81.89 ; U1.K21 212.09,75.9 ; U1.K21 212.59,76.39 ; U1.K21 212.59,75.9 ; U1.K21 212.09,76.39 ; 206.36,80.54 U1.AC12 ; U1.AC12 206.03,80.21 ; U1.AC12 206.03,80.54 ; U1.AC12 206.36,80.21 ; 182.86,69.06 U1.CL35 ; U1.CL35 182.86,69.56 ; U1.CL35 182.36,69.56 ; U1.CL35 182.36,69.06 ; U1.CG11 184.94,80.96 ; U1.CG11 184.45,81.46 ; U1.CG11 184.47,80.99 ; U1.CN35 181.45,69.06 ; U1.CN35 181.95,69.56 ; U1.CN35 181.95,69.06 ; U1.CN35 181.45,69.56 ; U1.K27 212.09,73.15 ; U1.K27 212.59,73.65 ; U1.K27 212.59,73.15 ; U1.K27 212.09,73.65 ; 191.35,81.46 U1.BP11 ; U1.BP11 190.85,80.96 ; U1.BP11 191.35,80.96 ; U1.BP11 190.85,81.46 ; U1.BW9 188.11,81.89 ; U1.BW9 188.11,82.39 ; U1.BW9 188.6,82.39 ; U1.BW9 188.6,81.89 ; 189.94,81.46 U1.BT11 ; U1.BT11 190.43,81.46 ; U1.BT11 190.43,80.96 ; U1.BT11 189.94,80.96 ; 213.05,72.28 U1.J30 ; U1.J30 213,71.83 ; U1.J30 212.55,71.78 ; U1.J30 212.55,72.28 ; U1.BN10 191.74,81.49 191.74,81.41 ; U1.BN10 191.75,81.86 191.75,81.94 ; U1.BN10 191.31,81.43 ; U1.BN10 191.31,81.92 ; U1.CE34 185.36,70.21 ; U1.CE34 185.36,69.71 ; U1.CE34 185.86,70.21 ; U1.CE34 185.86,69.71 ; 212.59,74.56 U1.K24 ; U1.K24 212.09,74.56 ; U1.K24 212.09,74.07 ; U1.K24 212.59,74.07 ; 184.94,69.06 U1.CG35 ; U1.CG35 184.94,69.56 ; U1.CG35 184.44,69.56 ; U1.CG35 184.44,69.06 ; U1.CK10 183.11,81.89 ; U1.CK10 183.12,81.47 ; U1.CK10 183.53,81.46 ; U1.CK10 183.57,81.87 ; 212.09,77.31 U1.K19 ; U1.K19 212.59,77.31 ; U1.K19 212.09,76.81 ; U1.K19 212.59,76.81 ; 190.39,81.92 U1.BR10 ; U1.BR10 190.89,81.43 ; U1.BR10 190.39,81.43 ; U1.BR10 190.89,81.92 ; 207.28,80.54 U1.AA12 ; U1.AA12 206.95,80.54 ; U1.AA12 206.95,80.21 ; U1.AA12 207.28,80.21 ; 181.03,70.21 U1.CR34 ; U1.CR34 181.03,69.71 ; U1.CR34 180.53,69.71 ; U1.CR34 180.53,70.21 ; U1.CG34 184.44,70.21 ; U1.CG34 184.94,70.21 ; U1.CG34 184.44,69.71 ; U1.CG34 184.94,69.71 ; 212.55,74.11 U1.J26 ; U1.J26 213,74.05 ; U1.J26 213.05,73.61 ; U1.J26 212.55,73.61 ; U1.CC36 186.27,68.68 ; U1.CC36 186.53,68.93 186.75,68.71 ; U1.CC36 186.52,68.93 186.31,68.72 ; U1.CC36 186.77,69.18 ; U1.CC36 186.27,69.18 ; 206.82,80.08 U1.AB13 ; U1.AB13 206.49,80.08 ; U1.AB13 206.82,79.75 ; 212.59,75.48 U1.K23 ; U1.K23 212.59,74.98 ; U1.K23 212.09,75.48 ; U1.K23 212.09,74.98 ; 187.69,82.39 U1.CA9 ; U1.CA9 187.19,81.89 ; U1.CA9 187.69,81.89 ; 185.86,69.56 U1.CE35 ; U1.CE35 185.36,69.56 ; U1.CE35 185.86,69.06 ; U1.CE35 185.36,69.06 ; 208.48,80.23 U1.V13 208.23,79.91 ; 189.02,82.39 U1.BV9 ; U1.BV9 189.52,81.89 ; U1.BV9 189.02,81.89 ; U1.BV9 189.52,82.39 ; U1.J22 213.05,75.44 ; U1.J22 212.55,75.44 ; U1.J22 212.55,75.94 ; 187.21,68.7 187.44,68.93 U1.CA36 ; U1.J18 212.55,77.27 ; U1.J18 213.05,77.27 ; U1.J18 213.04,77.75 ; U1.J18 212.55,77.77 ; U1.J23 212.55,75.02 ; U1.J23 212.83,74.77 213.05,75 213.05,75.02 ; U1.J23 212.55,74.52 ; 188.56,81.92 U1.BW10 189.06,81.92 ; 212.62,71.3 U1.J32 213,71.32 ; U1.K31 212.09,71.82 ; U1.K31 212.09,71.32 ; U1.K31 212.59,71.82 ; U1.J28 212.55,73.19 ; U1.J28 213.05,73.19 ; U1.J28 213.05,72.69 ; U1.J28 212.55,72.69 ; U1.BV36 189.52,69.18 ; U1.BV36 189.27,68.93 189.5,68.7 ; U1.BV36 189.02,69.18 ; U1.BV36 189.04,68.7 ; U1.BP9 190.85,81.89 ; U1.BP9 191.35,82.39 ; U1.BP9 190.85,82.39 ; U1.BP9 191.35,81.89 ; 180.12,69.71 U1.CT34 179.62,70.21 ; 187.69,69.18 U1.CA36 ; U1.CA36 187.19,69.18 ; U1.CA36 187.67,68.7 ; 181.03,69.06 U1.CR35 ; U1.CR35 180.53,69.56 ; U1.CR35 181.03,69.56 ; U1.CR35 180.53,69.06 ; 187.65,81.92 U1.BY10 188.15,81.92 ; 183.99,81.43 U1.CH10 184.49,81.43 ; 186.77,81.89 U1.CC9 186.28,81.89 ; 183.53,81.46 183.53,81.46 ; U1.BU10 189.48,81.92 ; U1.BU10 189.98,81.92 ; U1.BU10 189.98,81.43 ; 213.05,76.85 U1.J20 ; U1.J20 212.55,76.35 ; U1.J20 213,76.41 ; U1.J20 212.55,76.85 ; 183.78,69.56 U1.CJ35 ; U1.CJ35 183.78,69.06 ; U1.CJ35 183.28,69.56 ; U1.CJ35 183.28,69.06 ; U1.W12 207.86,80.21 ; U1.W12 207.86,80.54 ; U1.W12 208.19,80.54 ; U1.W12 208.19,80.21 ; 212.09,77.73 U1.K17 212.59,77.73 ; 207.4,80.08 U1.Y13 ; U1.Y13 207.4,79.75 ; U1.Y13 207.74,79.75 ; U1.Y13 207.74,80.08 ; 180.12,69.56 U1.CT35 180.12,69.06
  TOP w0.127: 180.11,70.19 179.88,69.96 U1.CT34
  TOP w0.203: U1.H19 v1(213.57,77.55) ; U1.G1 v1(214.55,85.64) ; U1.A24 v1(217.49,74.77) ; U1.D23 v1(215.54,75.69) ; v1(209.36,86.51) 209.29,86.43 209.29,86.01 209.2,85.93 U1.U1 ; U1.C19 v1(216.19,77.52) ; U1.D21 v1(215.54,76.6) ; U1.F21 v1(214.89,76.6) ; v1(214.24,73.86) 214.24,73.85 213.92,73.41 U1.G27 ; U1.C23 v1(216.19,75.69) ; U1.B23 v1(216.84,75.69) ; U1.H23 v1(213.59,75.69) ; U1.C29 v1(216.19,72.94) ; U1.F23 v1(214.89,75.69) ; U1.A23 217.41,75.58 v1(217.49,75.69) ; v1(217.49,73.86) 217.17,73.41 U1.A27 ; v1(213.59,73.86) 213.27,73.41 U1.H27 ; U1.D24 v1(215.54,74.77) ; U1.F24 v1(214.89,74.77) ; U1.D27 215.22,73.41 v1(215.54,73.86) ; U1.D29 v1(215.54,72.94) ; U1.B29 v1(216.84,72.94) ; v1(223.01,112.9) 223.25,112.9 223.53,112.62 223.53,111.79 223.4,111.65 221.28,111.65 220.05,110.42 220.05,102.74 220.01,102.7 220.01,102.69 217.98,100.66 213.38,100.66 212.96,100.24 LPM3.2 ; U1.B27 216.52,73.41 v1(216.84,73.86) ; U1.A29 v1(217.49,72.94) ; U1.G23 v1(214.24,75.69) ; v1(216.19,73.86) 215.87,73.41 U1.C27 ; U1.AB1 206.73,86.36 206.64,86.81 v1(206.65,86.82) ; v1(212.07,87.21) 212.07,86.89 211.69,86.51 211.69,85.81 U1.M1 ; U1.B19 v1(216.84,77.52) ; U1.H29 v1(213.59,72.94) ; U1.A21 v1(217.49,76.6) ; U1.F29 v1(214.89,72.94) ; U1.D19 v1(215.54,77.52) ; U1.F27 214.57,73.41 v1(214.89,73.86) ; U1.G29 v1(214.24,72.94)
  TOP w0.305: v1(185.57,101.51) 184.58,101.51 184.04,100.97 LPM2.2 ; LPM1.2 193.01,98.33 193.01,101.44 v1(192.87,101.58) ; 188.08,69.14 188.28,68.93 U1.BW36
  ART03 w0.203: NS2.1 215.41,102.77 215.85,102.77 215.99,102.63 215.99,102.43 214.26,100.7 214.26,98.44 216.6,96.1 223.42,96.1 224.88,94.64 224.88,90.05 222.07,87.24 222.07,86.23 220.9,85.06 220.9,85.05 220.65,84.8 220.65,81.27 218.62,79.24 218.62,77.83 218.31,77.52 v1(216.84,77.52)
  ART06 w0.203: v1(218.57,112.89) 218.42,112.74 218.42,111.94 217.02,110.53 189.07,110.53 187.21,108.68 187.21,102.26 186.7,101.75 185.81,101.75 v1(185.57,101.51) ; v1(192.87,101.58) 192.98,101.7 194.15,101.7 194.5,102.04 194.5,102.96 192.39,105.07 189.17,105.07 188.38,105.86 188.38,108.03 189.83,109.48 219.26,109.48 221.13,111.35 222.2,111.35 222.56,110.99 222.56,110.05 v1(222.28,109.76)
  BOTTOM w0.305: v1(223.01,112.9) 223.01,113.23 223.41,113.64 224.63,113.64 225.23,113.03 PR2.2 225.47,113.03 PC39.1 226.29,113.04 R785.2 227.11,113.04 PC61.1 ; v1(218.57,112.89) 218.57,111.32 218.31,111.06 218.31,110.81 PR54.1 218.21,110.71 PC21.1 219.21,110.71 R784.2 220.31,110.71 PC59.1 ; PC58.1 R781.2 220.5,108.72 PC8.1 221.3,108.72 PR31.1 222.07,109.56 v1(222.28,109.76)
  vias: v1(180.32,69.64) v1(180.32,69) v1(181.23,69.64) v1(181.23,69) v1(182.15,69.64) v1(182.15,69) v1(183.06,69.64) v1(183.08,69.15) v1(183.99,69.71) v1(184.02,69.23) v1(184.31,80.61) v1(184.83,80.62) v1(185.17,69.94) v1(185.19,69.46) v1(185.33,80.76) v1(185.96,70.75) v1(186.13,80.81) v1(186.14,69.99) v1(186.19,69.49) v1(186.86,80.58) v1(187.39,80.68) v1(187.44,69.55) v1(187.89,82.38) v1(187.9,80.86) v1(188.35,69.53) v1(188.65,80.73) v1(188.8,82.38) v1(189.27,69.53) v1(189.75,81) v1(190.25,80.59) v1(190.64,81.17) v1(190.96,80.58) v1(191.55,82.37) v1(206.63,79.29) v1(207.12,79.67) v1(207.61,79.31) v1(211.25,75.92) v1(211.24,73.64) v1(211.26,76.98) v1(211.26,74.82) v1(211.26,72.63) v1(211.82,77.52) v1(211.82,76.44) v1(211.82,75.36) v1(211.82,74.28) v1(211.82,73.2) v1(211.82,72.12) v1(211.82,71.11) v1(216.21,71.09) v1(216.8,71.12) v1(219.02,75.85) v1(219.28,72.94) v1(219.91,75.85) v1(220,71.82) v1(220.85,75.85) v1(221.78,78.91) v1(221.81,78.04) v1(221.78,76.06) v1(221.77,74.2) v1(222.03,71.86) v1(223.64,78.34) v1(223.56,71.97) v1(223.95,77.31) v1(223.95,76.71) v1(223.98,75.41) v1(224.01,74.83) v1(224.02,73.64) v1(224.02,73.04) v1(224.44,78.34) v1(224.75,74.23) v1(224.91,76.13) v1(225.34,78.36) v1(225.4,72.33) v1(227.09,77.31) v1(227.09,76.71) v1(227.09,75.4) v1(227.09,74.8) v1(227.09,73.62) v1(227.09,73.02) v1(228.01,77.37) v1(228.01,76.53) v1(228.01,75.64) v1(228.01,74.81) v1(228.01,73.89) v1(228,73.21) v1(228.02,72.37) v2(188.01,95.52) v2(188.26,96.31) v2(188.72,95.52) v2(189.13,96.28) v2(189.26,94.65) v2(189.29,93.91) v2(189.42,95.49) v2(189.97,94.65) v2(190,93.91) v2(190.67,94.62) v2(190.7,93.88) v2(191.41,93.86) v2(191.59,94.67) v2(192.12,93.86) v2(192.42,94.63) v2(192.82,93.83) v2(193.28,94.61) v2(193.63,93.88) v2(194.09,94.6) v2(194.66,94.08) v2(195.1,94.65) v2(195.57,94.08) v2(195.96,94.69) v2(196.44,94.11) v2(196.86,94.68) v2(197.26,94.1) v2(199.3,93.8) v2(199.59,94.47) v2(200.02,93.82) v2(200.31,94.49) v2(200.73,93.82) v2(201.02,94.49) v2(201.43,93.79) v2(204.98,94.47) v2(205.01,93.58) v2(206.17,93.61) v2(206.43,94.39) v2(206.88,93.61) v2(207.24,94.31) v2(207.58,93.58) v2(207.96,94.25) v2(208.35,93.63) v2(208.71,94.32) v2(209.1,93.59) v2(209.48,94.32) v2(209.9,93.6) v2(210.65,93.62) v2(211.09,94.29) v2(211.73,93.69) v2(211.7,92.93) v2(212.14,94.42) v2(212.51,93.7) v2(212.49,92.93) v2(213.55,93.75) v2(213.56,93) v2(214.14,94.3) v2(214.56,93.66) v2(214.59,92.95) v2(215.49,93.69) v2(215.52,92.98) v2(215.83,94.39) v2(216.2,93.69) v2(216.23,92.98) v2(216.9,93.66) v2(216.93,92.94) v2(218.08,94.24) v2(218.13,93.43) v2(218.16,92.72) v2(218.95,93.83) v2(218.9,93.02) v2(218.92,92.27) v2(219.71,93.84) v2(219.76,93.09) v2(219.77,92.34) v2(219.94,91.62) v2(220,90.78) v2(220.5,93.83) v2(220.51,93.09) v2(220.51,92.38) v2(220.69,91.61) v2(220.75,90.79) v2(221.28,93.1) v2(221.31,92.39) v2(221.37,93.87) v2(221.43,91.6) v2(221.49,90.82) v2(221.54,84.18) v2(221.54,83.27) v2(222.32,81.49) v2(222.29,80.79) v2(222.29,80.08) v2(224.83,80.66) v2(224.83,79.95) v2(224.86,81.36) v2(226,75) v2(225.96,74.3) v2(225.96,73.59) v2(226.17,88.91) v2(226.17,87.99) v2(227.25,89.52) v2(227.31,88.61) v2(227.31,87.69) v2(227.44,80.76) v2(227.44,80.05) v2(227.47,81.46) v2(228.18,89.52) v2(228.24,88.6) v2(228.24,87.69) v2(228.83,85.06) v2(228.8,84.36) v2(228.8,83.65) v2(228.88,79.93) v2(228.88,79.01) v2(229.02,89.53) v2(229.08,88.62) v2(229.08,87.71) v2(229.65,73.19) v2(229.65,72.48) v2(229.68,73.89) v2(229.85,89.55) v2(229.9,88.64) v2(229.9,87.73) v2(230.05,81.07) v2(230.05,80.36) v2(230.03,77.03) v2(230.03,76.32) v2(230.14,86.48) v2(230.14,85.56) v2(230.09,81.77) v2(230.07,77.73)

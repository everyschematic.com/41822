# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N5766199: length 100.5
  TOP w0.076: v1(175.32,91.07) 175.54,90.84 176.79,90.84 177.12,90.51 177.12,89.42 178.44,88.11 178.44,86.37 178.55,86.25 U1.CW1
  TOP w0.109: C81.1 112.32,66.87 112.7,66.87 114.63,68.79 114.63,75.74 114.32,76.04 113.97,76.04 v1(113.85,76.17)
  ART03 w0.075: v1(175.32,91.07) 175.14,90.89 174.78,90.89 174.63,91.04 174.63,92.47 171.75,95.34 169.41,95.34 166.88,92.81 165.1,92.81 165.09,92.83 165.07,92.83
  ART03 w0.087: v1(113.85,76.17) 114.38,76.17 114.72,76.51 114.72,88.79 117.59,91.65 121.82,91.65 123.55,93.38 127.17,93.38 127.44,93.12 131.05,93.12 131.78,92.39 136.17,92.39 136.83,91.73 138.71,91.73 139.26,91.18 140.96,91.18 141.34,91.57 152.43,91.57 153.55,92.68 153.9,92.68 154.72,93.51 155.23,93.51 155.61,93.89 158.76,93.89 159.43,93.21 161.53,93.21 161.91,92.83 165.07,92.83
N5766235: length 102
  TOP w0.076: v1(175.8,89.04) 175.93,88.92 176.55,88.92 177.73,87.74 177.73,85.76 U1.DA2
  TOP w0.109: C73.1 112.38,71.84 112.79,71.84 112.94,71.99 112.94,73.78 111.67,75.05 111.67,75.58 111.4,75.85 111.26,75.85 v1(110.95,75.53)
  ART03 w0.075: 166.62,94.2 166.64,94.2 166.66,94.21 167.41,94.21 169.4,96.21 171,96.21 171.51,96.72 173.53,96.72 176.74,93.5 176.74,90.67 177.03,90.38 177.03,89.23 176.79,88.99 175.86,88.99 v1(175.8,89.04)
  ART03 w0.087: 166.62,94.2 163.51,94.2 162.69,95.03 155.11,95.03 154.78,94.7 153.56,94.7 152.74,93.87 150.53,93.87 149.54,92.88 141.01,92.88 140.28,93.61 132.37,93.61 131.7,94.28 128.27,94.28 127.5,95.05 123.33,95.05 121.3,93.02 117.06,93.02 111.72,87.68 111.72,76.08 111.38,75.74 111.15,75.74 v1(110.95,75.53)
N5766239: length 102.3
  TOP w0.076: U1.DA1 177.58,86.26 177.58,87.68 176.48,88.77 176.13,88.77 v1(175.8,88.44)
  TOP w0.109: v1(110.95,76.14) 111.01,76.07 111.49,76.07 111.89,75.67 111.89,75.14 113.16,73.87 113.16,71.9 112.88,71.63 112.22,71.63 C74.1
  ART03 w0.075: 166.62,94.38 166.64,94.38 166.66,94.36 167.34,94.36 169.34,96.36 170.94,96.36 171.45,96.87 173.59,96.87 176.9,93.57 176.9,90.75 177.2,90.44 177.2,89.16 176.86,88.82 176.19,88.82 v1(175.8,88.44)
  ART03 w0.087: 166.62,94.38 163.59,94.38 162.76,95.21 155.03,95.21 154.7,94.88 153.49,94.88 152.66,94.06 150.45,94.06 149.46,93.06 141.08,93.06 140.36,93.79 132.45,93.79 131.77,94.47 128.34,94.47 127.58,95.23 123.25,95.23 121.23,93.21 116.98,93.21 111.53,87.76 111.53,76.15 111.3,75.92 111.16,75.92 v1(110.95,76.14)
N5766259: length 101.7
  TOP w0.076: U1.CY3 177.99,85.57 177.92,85.65 177.92,85.7 177.93,85.71 177.93,87.82 176.43,89.31 176.43,89.79 176.3,89.92 176.12,89.92 v1(175.89,89.69)
  TOP w0.109: C77.1 112.21,69.56 112.21,69.56 112.59,69.18 113.29,69.18 113.69,69.59 113.69,74.13 112.41,75.42 v1(112.41,76.09)
  ART03 w0.075: 165.73,93.48 165.74,93.48 165.76,93.47 166.94,93.47 169.36,95.89 171.16,95.89 171.64,96.38 172.43,96.38 176.37,92.43 176.37,90.62 176.58,90.41 176.58,90.09 176.41,89.92 176.11,89.92 v1(175.89,89.69)
  ART03 w0.087: 165.73,93.48 162.55,93.48 161.82,94.21 159.46,94.21 159.12,94.56 155.33,94.56 154.95,94.18 153.73,94.18 151.95,92.39 137.18,92.39 136.48,93.09 132.06,93.09 131.38,93.78 127.87,93.78 127.19,94.46 123.61,94.46 121.67,92.52 117.52,92.52 112.72,87.72 112.72,76.4 v1(112.41,76.09)
N5766263: length 102.1
  TOP w0.076: v1(175.89,90.3) 176.11,90.08 176.37,90.08 176.59,89.86 176.59,89.38 178.08,87.88 178.08,85.77 178.28,85.57 178.28,84.92 177.99,84.63 U1.CY4
  TOP w0.109: v1(113.01,76.09) 112.62,75.71 112.62,75.51 113.91,74.23 113.91,69.5 113.38,68.96 C78.1
  ART03 w0.075: v1(175.89,90.3) 176.11,90.07 176.35,90.07 176.43,90.16 176.43,90.35 176.22,90.56 176.22,92.37 172.36,96.22 171.7,96.22 171.22,95.74 169.43,95.74 167,93.31 165.76,93.31 165.74,93.3 165.73,93.3
  ART03 w0.087: v1(113.01,76.09) 112.9,76.2 112.9,87.64 117.6,92.34 121.75,92.34 123.69,94.28 127.11,94.28 127.8,93.59 131.3,93.59 131.98,92.91 136.4,92.91 137.1,92.21 152.03,92.21 153.81,93.99 155.03,93.99 155.41,94.37 159.05,94.37 159.39,94.03 161.74,94.03 162.47,93.3 165.73,93.3
N5807743: length 5
  TOP w0.076: C71.1 179.95,89.68 179.69,89.42 179.69,89.17 179.81,89.05 180.09,89.05 180.31,88.83 180.31,88.66 180.32,88.64 180.32,85.84 180.13,85.65 179.99,85.65 179.9,85.56 U1.CT2
N5807747: length 4.8
  TOP w0.076: U1.CT1 179.9,85.92 179.99,85.83 180.06,85.83 180.15,85.92 180.15,88.64 180.16,88.66 180.16,88.76 180.03,88.9 179.75,88.9 179.53,89.11 179.53,89.34 C72.1
N5807759: length 92.9
  TOP w0.076: U1.CT3 179.75,84.96 179.75,85.14 179.64,85.36 179.64,85.38 179.64,85.57 179.66,85.62 179.68,85.88 179.63,86.01 179.63,86.28 179.9,86.55 179.9,88.25 179.69,88.47 179.44,88.47 v1(179.24,88.67)
  TOP w0.109: C64.1 131.42,86.63 126.01,86.63 125.46,86.09 122.73,86.09 121.1,87.72 121.1,95.07 v1(120.84,95.32)
  ART03 w0.075: v1(179.24,88.67) 179,88.43 178.89,88.43 178.38,88.94 178.38,89.85 177.24,90.98 177.24,93.92 173.93,97.23 171.17,97.23 170.78,96.84 169.31,96.84 169.31,96.84 169.18,96.84 169.14,96.81 169.14,96.81 168.4,96.07 168.37,96.07 167.37,95.07 167.31,95.07
  ART03 w0.087: v1(120.84,95.32) 121.05,95.53 121.05,96.01 121.41,96.37 122.37,96.37 122.82,95.92 128.25,95.92 129.02,95.15 132.06,95.15 132.69,94.52 140.83,94.52 141.53,93.82 149.07,93.82 150.08,94.83 152.34,94.83 153.05,95.54 154.44,95.54 155.81,96.91 159.55,96.91 160.46,96.01 162.89,96.01 163.83,95.07 167.31,95.07
N5807763: length 92.9
  TOP w0.076: U1.CT5 180.04,84.3 180.04,84.45 179.97,84.52 179.75,84.52 179.62,84.66 179.62,84.7 179.59,85.06 179.52,85.21 179.46,85.32 179.46,85.38 179.46,85.61 179.49,85.67 179.5,85.85 179.46,85.99 179.46,86.36 179.73,86.63 179.73,88.18 179.62,88.29 179.43,88.29 179.24,88.1 v1(179.24,88.03)
  TOP w0.109: v1(121.44,95.32) 121.32,95.2 121.32,87.81 122.82,86.3 125.37,86.3 125.92,86.85 131.42,86.85 C65.1
  ART03 w0.075: v1(179.24,88.03) 179,88.28 178.83,88.28 178.23,88.88 178.23,89.79 177.09,90.92 177.09,93.85 173.87,97.08 171.24,97.08 170.84,96.68 169.24,96.68
  ART03 w0.087: v1(121.44,95.32) 121.23,95.53 121.23,95.94 121.48,96.18 122.29,96.18 122.74,95.74 128.18,95.74 128.95,94.96 131.98,94.96 132.61,94.33 140.75,94.33 141.45,93.64 149.14,93.64 150.16,94.65 152.42,94.65 153.12,95.36 154.51,95.36 155.89,96.73 159.47,96.73 160.38,95.82 162.81,95.82 163.75,94.89 167.44,94.89 169.24,96.68
N5816743: length 1.1
  BOTTOM w0.305: R81.2 216.63,62.88 C48.1
N5816815: length 0.8
  BOTTOM w0.305: C85.1 216.14,65.99 R87.2
N5816861: length 2.5
  TOP w0.3: U1.B45 216.36,64.27 v1(215.81,64.27)
  BOTTOM w0.305: v1(215.81,64.27) 215.2,64.88 R45.1 215.2,65.2 C85.2
N5825064: length 3.3
  TOP w0.076: v1(217.63,85.86) 217.26,85.48 217.15,85.48 216.88,85.22 216.27,85.22 U1.C3
  BOTTOM w0.075: v1(217.63,85.86) 218.43,86.65 R151.2
N5825723: length 6.4
  TOP w0.076: U1.CR38 v1(181.23,67.73)
  BOTTOM w0.075: R154.2 178.26,64.29 178.26,64.74 178.51,64.98 179.05,64.98 179.74,65.67 179.74,66.08 179.89,66.23 179.89,67.04 180.13,67.28 180.78,67.28 v1(181.23,67.73)
N7408241: length 34.6
  TOP w0.075: 174.38,56.42 174.38,55.81 173.68,55.11
  TOP w0.076: U1.DA47 177.34,63.39 177.34,60.55 174.38,57.58 174.38,56.42
  TOP w0.102: R278.2 R252.2 153.29,56.78 156.39,53.69 162.79,53.69 163.46,54.35 165.91,54.35 166.9,53.36 171.93,53.36 173.68,55.11
N7408375: length 34
  TOP w0.075: 172.96,54.08 174.63,55.75 174.63,57.45 177.83,60.65 177.83,61.91 177.93,62 177.93,63.5 178.27,63.85 U1.CY46
  TOP w0.102: 172.96,54.08 171.86,52.98 163.75,52.98 163.32,53.41 156.19,53.41 153.58,56.01 R266.2
N7411390: length 0.8
  TOP w0.075: v1(167.71,74.11) 168.01,74.4 U1.DW24
N7411394: length 28.2
  TOP w0.076: v1(173.52,74.88) 173.17,75.23 U1.DK22
  ART03 w0.102: v1(173.52,74.88) 173.52,74.59 173.2,74.27 172.63,74.27 172.26,73.91 170.26,73.91 170.11,74.05 169.48,74.05 169.11,73.67 167.59,73.67 167.22,74.04 164.26,74.04 164.01,74.28 161.56,74.28 161.09,73.81 159.13,73.81 157.46,72.14 153.95,72.14 153.79,71.98 151.85,71.98 v1(149.71,69.84)
  BOTTOM w0.102: v1(149.71,69.84) 149.57,69.84 149.04,69.31 R1390.2
N7416143: length 9.8
  TOP w0.075: R286.1 163.79,71.98 164.4,71.36 v1(164.76,71.36)
  TOP w0.076: U1.DL31 v1(172.21,71.22)
  ART03 w0.102: v1(164.76,71.36) 165.59,70.53 170.95,70.53 171.27,70.85 171.84,70.85 v1(172.21,71.22)
N7416157: length 3.5
  TOP w0.076: v1(172.21,72.14) 172.21,72.14 U1.DL29
  BOTTOM w0.075: R173.1 169.93,72.25 170.4,71.78 171.86,71.78 v1(172.21,72.14)
N7416165: length 10.5
  TOP w0.075: U1.DP31 171.22,71.53 v1(170.91,71.22)
  TOP w0.102: R284.1 162.1,72.38 164.12,72.38 v1(164.34,72.16)
  ART03 w0.102: v1(170.91,71.22) 170.5,70.81 166.67,70.81 165.09,72.39 164.58,72.39 v1(164.34,72.16)
N7416179: length 9
  TOP w0.076: v1(171.56,72.14) 171.56,72.14 U1.DN29
  TOP w0.102: v1(164.44,72.77) 163.82,72.77 R287.1
  ART03 w0.102: v1(171.56,72.14) 171.2,71.77 170.76,71.77 170.58,71.96 169.66,71.96 169.54,71.84 166.02,71.84 165.09,72.77 v1(164.44,72.77)
N7426175: length 8
  TOP w0.075: 182.25,62.51 182.24,62.49 182.24,60.39 182.1,60.25 182.1,60.22 180.36,58.48 180.33,58.48 179.98,58.13 179.98,58.04 179.56,57.62
  TOP w0.076: U1.CL45 182.65,64.12 182.37,63.84 182.37,63.76 182.32,63.72 182.32,62.81 182.3,62.67 182.25,62.58 182.25,62.51
N7426185: length 24.2
  TOP w0.076: U1.DF47 175.14,63.81 174.86,64.09 174.86,64.25 v1(174.62,64.49)
  TOP w0.102: R83.1 157.04,65.55 157.04,64.62 v1(156.89,64.47)
  ART03 w0.102: v1(156.89,64.47) 156.89,63.2 158.88,61.22 162.26,61.22 163.41,62.37 165.2,62.37 166.24,63.4 173.22,63.4 174.3,64.49 v1(174.62,64.49)
N7426195: length 3.3
  TOP w0.076: U1.DC48 176.4,62.77 176.63,62.53 176.63,62.13 176.91,61.85 176.91,61.19 176.59,60.86 176.23,60.86 R103.1
N7426445: length 5.9
  TOP w0.076: U1.DM49 172.06,62.35 171.93,62.23 171.93,61.62 171.19,60.88 169.73,60.88 v1(169.49,60.64)
  BOTTOM w0.203: R101.2 169.84,60.98 v1(169.49,60.64)
N7429515: length 196.3
  TOP w0.075: R439.1 R150.1 165.11,60.16 R22.2 165.7,59.57 166.34,59.57 167.02,58.89 169.2,58.89 169.77,58.32 170.36,58.32 170.93,58.89
  TOP w0.076: U1.DL45 173.42,64.33 173.63,64.13 173.63,63.9 173.54,63.82 173.54,62.61 173.51,62.53 173.45,62.4 173.45,62.12 173.6,61.97 173.6,61.57 172.94,60.91 172.94,60.89 170.93,58.89
  TOP w0.102: R223.1 96.37,60.97 95.53,60.13 95.53,57.33 94.8,56.6 94.67,56.6 v1(94.59,56.51) ; v1(160.94,58.81) 160.98,58.86 163.15,58.86 163.57,59.27 R439.1 ; v1(126.86,102.99) 126.99,102.99 127.17,102.81 R4.1
  ART03 w0.102: v1(160.94,58.81) 160.16,59.59 155.04,59.59 154.37,58.92 152.32,58.92 151.28,59.96 149.09,59.96 148.77,59.64 146.1,59.64 145.19,60.54 137.47,60.54 136.45,59.52 130.4,59.52 129.33,58.45 127.75,58.45 125.58,56.29 124.24,56.29 123.31,55.36 111.38,55.36 110.77,54.75 106.19,54.75 104.53,56.4 98.23,56.4 97.89,56.74 95.11,56.74 94.87,56.5 94.6,56.5 v1(94.59,56.51)
  ART06 w0.102: v1(94.59,56.51) 94.56,56.54 94.56,56.86 94.08,57.33 78.27,57.33 v1(78.17,57.24) ; v1(160.94,58.81) 160.55,58.42 158.45,58.42 158.01,58.86 156.47,58.86 155.33,60 151.16,60 145.81,65.34 144.4,65.34 142.4,67.34 141.46,67.34 140.05,68.75 140.05,75.32 139.75,75.62 139.75,83.98 138.61,85.13 137.57,85.13 129.88,92.82 127.27,92.82 125.64,94.45 125.64,96.21 126.33,96.9 126.33,97.3 125.78,97.85 125.78,101.83 126.86,102.9 v1(126.86,102.99)
  BOTTOM w0.127: v1(78.17,57.24) 79.19,58.25 79.19,59.62 77.66,61.16 77.66,61.65 76.43,62.87 73.97,62.87 73.78,63.06 73.78,64.7 R243.1
N7506400: length 1.4
  TOP w0.075: U1.DU47 169.72,63.91 v1(169.52,64.1)
  BOTTOM w0.075: R850.2 169.52,64.82 v1(169.52,64.1)
N7506448: length 3.2
  TOP w0.203: U1.C16 216.5,78.94 216.5,78.95 217.35,78.95 217.37,78.97
  TOP w0.305: 217.37,78.97 218.13,78.97 218.44,79.29 R852.2
N7506460: length 2.4
  TOP w0.203: U1.A16 216.96,78.51
  TOP w0.305: 216.96,78.51 R851.2
N7506476: length 1.2
  TOP w0.075: U1.J15 v1(213.53,78.53)
  BOTTOM w0.305: R848.2 213.41,78.65 v1(213.53,78.53)
N7507062: length 0.9
  TOP w0.076: v1(208.94,82.4) 209.2,82.14 U1.T9
  BOTTOM w0.127: v1(208.94,82.4) 209.31,82.4 TP52.1
N7562818: length 2
  TOP w0.076: v1(213.66,86.55) 213.7,86.51 213.7,86.34 U1.H1
  BOTTOM w0.102: R307.1 212.53,85.92 213.2,86.59 213.62,86.59 v1(213.66,86.55)
N7628615: length 28.9
  TOP w0.305: PR96.1 v1(200.85,106.24)
  ART03 w0.203: v1(224.96,106.56) 224.21,107.3 223.59,107.3 223.18,106.9 206.03,106.9 204.57,105.44 201.65,105.44 v1(200.85,106.24)
  BOTTOM w0.203: v1(224.96,106.56) 224.99,106.52 224.99,106.32 224.5,105.83 U3.27
  BOTTOM w0.305: PR95.1 225.03,106.56 v1(224.96,106.56)
N7628623: length 0.9
  BOTTOM w0.305: PR97.1 225.99,109.13 PR115.2
N7628627: length 0.9
  BOTTOM w0.305: PR94.1 225.21,110.09 PR114.2
N7628631: length 27.3
  TOP w0.203: 201.8,106.27 v1(201.8,106.28)
  TOP w0.305: PR96.2 201.8,106.27
  ART03 w0.203: v1(201.8,106.28) 202.24,105.84 204.53,105.84 205.92,107.22 223.05,107.22 223.45,107.63 224.39,107.63 224.71,107.95 v1(224.71,108.76)
  BOTTOM w0.305: PR114.1 224.83,108.76 v1(224.71,108.76) 224.71,108.61 PR97.2 225.04,107.52 PR95.2
N7632263: length 6
  BOTTOM w0.203: U3.28 224.9,105.76 225.35,106.21
  BOTTOM w0.305: PC15.1 227.06,107.57 226.3,106.82 225.96,106.82 225.35,106.21
  BOTTOM w0.406: PR41.1 227.76,109.12 227.76,108.28 PC15.1
N7679261: length 30.3
  TOP w0.203: v1(188.78,101.42) 188.64,101.29 PR100.1
  ART06 w0.203: v1(216.16,99.13) 216.17,99.11 216.17,98.84 215.94,98.61 193.29,98.61 190.37,101.54 188.89,101.54 v1(188.78,101.42)
  BOTTOM w0.203: PR101.2 216.48,99.61 216.16,99.29 v1(216.16,99.13)
N7679265: length 2.2
  BOTTOM w0.305: PR101.1 217.4,99.62 217.03,99.99 217.03,99.99 216.87,100.15 216.87,100.15 PR102.2 215.7,100.55 PR103.1
N7679401: length 1.1
  BOTTOM w0.305: PR102.1 217.54,100.55 218.06,100.04 PR113.2
N7695190: length 2.6
  BOTTOM w0.305: PU3.8 204.75,105.45 204.92,105.62
  BOTTOM w0.508: PR12.1 204.4,106.22 PC14.1 204.92,105.62
N7695204: length 1.6
  BOTTOM w0.305: PU3.1 206.77,105.25 206.92,105.39 207.97,105.39 PR11.2
N7695220: length 1.4
  BOTTOM w0.254: PR10.2 207.12,103.75 PU3.4
N7695396: length 1
  BOTTOM w0.508: PC12.1 210.25,103.12 PR10.1
N7794394: length 3.5
  TOP w0.508: PR36.2 157.63,111.09 PR38.2 157.63,109.57 156.43,108.37 Q22.4
N7794398: length 4.6
  TOP w0.305: PR40.2 161.36,111.42 PR57.2
  TOP w0.508: PR40.2 162.14,110.48 162.69,109.92 C6135.1 163.17,108.76 163.46,108.47 Q23.4
N7795972: length 2.2
  BOTTOM w0.203: U6.10 166.2,98.63
  BOTTOM w0.305: 166.2,98.63 166.54,98.63
  BOTTOM w0.508: PR32.2 167.06,98.76 166.93,98.63 166.54,98.63
N7795976: length 1.1
  BOTTOM w0.508: PC50.1 167.06,101.81 PR32.1
N7796574: length 10
  BOTTOM w0.203: U6.5 163.34,97.44 163.34,97.81 162.5,98.65 162.5,99.28 161.44,100.34 157.31,100.34 PC54.2 156.41,101.25 PC62.2
N7796578: length 11.3
  BOTTOM w0.203: PC54.1 157.36,100.79 157.46,100.69 161.6,100.69 162.87,99.42 162.87,98.84 163.08,98.62 163.79,98.62 164.05,98.36 U6.6
  BOTTOM w0.305: PC54.1 158.22,101.24 PR108.1 158.22,102.05 PC63.2 158.23,102.84 PR63.2
N7796616: length 0.8
  BOTTOM w0.305: PR63.1 157.36,102.8 PC62.1
N7797282: length 2
  BOTTOM w0.203: PR69.1 PR66.2 164.45,98.97 U6.7
N7798637: length 3.5
  BOTTOM w0.203: U6.20 163.56,95.13 163.29,94.87
  BOTTOM w0.508: 163.29,94.87 162.51,94.87 PC55.1 162.04,94.4 R329.1
N7841228: length 3.8
  TOP w0.102: v1(43.13,72.85) 43.98,72.85 R330.1
  BOTTOM w0.203: U9.56 40.92,72.85 41.07,72.71 42.98,72.71 v1(43.13,72.85)
N7843299: length 1.9
  BOTTOM w0.114: TP1.1 53.16,60.56 53.16,61.29 52.96,61.48 U9.4
N7844015: length 3.7
  BOTTOM w0.102: U9.125 56.82,64.85 57.12,64.56 57.12,64 R355.1 58.48,63.54 R352.2
N7844027: length 11
  BOTTOM w0.102: R349.2 55.77,83.42 R350.1 55.33,83.43 55.12,83.22 55.12,80.49 55.26,80.35 55.26,76.66 54.71,76.11 54.71,75.11 54.97,74.85 U9.100
N7847497: length 1.7
  BOTTOM w0.102: U9.1 54.16,61.41 R356.2
N7847611: length 2.8
  BOTTOM w0.102: C9.1 49.76,59.56 U9.12
N7887361: length 4.4
  BOTTOM w0.102: U9.25 44.56,61.13 44.34,60.9 43.28,60.9 42.33,59.96 R91.1
N7888127: length 2
  TOP w0.102: v1(56.88,67.69) 56.88,67.79 56.75,67.91 R237.1
  BOTTOM w0.102: U9.117 56.61,68.05 56.88,67.79 v1(56.88,67.69)
N7888705: length 5.2
  BOTTOM w0.102: U9.67 42.56,78.17 42.35,78.38 40.23,78.38 39.93,78.68 R15.1
N7889662: length 2.5
  TOP w0.102: v1(57.24,75.7) 57.29,75.75 R157.2
  BOTTOM w0.102: U9.97 56.43,76.05 56.52,76.14 56.99,76.14 57.24,75.89 v1(57.24,75.7)
N7929493: length 1.4
  BOTTOM w0.203: 162.65,95.66 162.72,95.66 162.86,95.81 U6.1
  BOTTOM w0.508: 162.65,95.66 162.6,95.6 162.14,95.6 R375.2
N7931680: length 2.2
  BOTTOM w0.102: R79.1 57.45,72.05 U9.107
N8120641: length 4
  TOP w0.109: v1(201.94,30.12) 202.47,30.65 CN11.166
  BOTTOM w0.102: v1(201.94,30.12) 202.33,29.73 R734.1 202.33,29.46 R736.1
N8123009: length 2
  TOP w0.102: v1(183.22,25.38) 183.22,25.37 183.22,24.05 CN11.97
  BOTTOM w0.109: v1(183.22,25.38) 183.22,24.76 R750.1
N8123013: length 3.4
  TOP w0.102: CN11.95 182.72,24.05 182.72,26.06 v1(183.22,26.55)
  BOTTOM w0.109: v1(183.22,26.55) 183.21,26.54 R751.1
N8123041: length 1.9
  TOP w0.127: CN11.134 192.47,33.42 v1(192.43,33.46)
  BOTTOM w0.109: v1(192.43,33.46) 192.4,33.43 R733.2
N8132326: length 3.7
  TOP w0.254: CN19.166 202.47,19.11 202.21,18.84 v1(201.97,18.84)
  BOTTOM w0.305: R236.1 R285.1 202.34,18.87 202,18.87 v1(201.97,18.84)
N8133152: length 4.4
  TOP w0.254: v1(192.36,17.08) 192.47,17.2 192.47,17.47 192.46,17.49 192.46,20.7 CN19.134
  BOTTOM w0.102: v1(192.36,17.08) 192.36,17.22 192.21,17.37 R229.2
N8136392: length 1.9
  TOP w0.102: CN19.97 183.22,13.83 v1(183.22,13.84)
  BOTTOM w0.109: v1(183.22,13.84) 183.52,13.53 R302.1
N8136396: length 3.9
  TOP w0.102: v1(183.22,15.01) 183.04,15.01 182.72,14.7 CN19.95
  BOTTOM w0.305: R303.1 182.58,14.51 183.09,15.01 v1(183.22,15.01)
N8195134: length 37.9
  TOP w0.076: 176.47,53.86 176.35,53.98 176.35,57.34 179.02,60 179.6,60 180.22,60.62 180.22,61.4 180.06,61.56 180.06,62.3 U1.CT49
  TOP w0.102: R414.2 153.82,50.09 153.95,49.96 158.61,49.96 158.83,50.18 161.4,50.18 162.3,49.29 173,49.29 176.47,52.76 176.47,53.86
N8195691: length 40
  TOP w0.075: 176.15,54.32 176.15,54.26
  TOP w0.076: 176.15,54.32 176.15,57.35 178.95,60.15 179.52,60.15 180.06,60.7 180.06,61.32 179.88,61.5 179.88,62.35 179.92,62.55 179.97,62.6 180.14,62.77 U1.CT48
  TOP w0.102: R214.2 152.55,50.56 152.75,50.36 153.83,50.36 154.03,50.17 158.48,50.17 158.7,50.39 161.57,50.39 162.46,49.5 172.69,49.5 176.15,52.96 176.15,54.26
N8195853: length 39.9
  TOP w0.075: 175.02,52.94 175.69,53.61 175.69,57.42 179.08,60.8 179.08,61.2 179.34,61.47 179.34,62.23 179.2,62.38 179.2,63.45 178.97,63.68 U1.CV47
  TOP w0.102: 175.02,52.94 172.28,50.2 162.51,50.2 161.05,51.66 158.79,51.66 157.71,50.59 154.88,50.59 153.94,51.53 152.82,51.53 152.74,51.45 R416.2
N8195919: length 38.4
  TOP w0.075: 175.92,55.83 175.92,53.29
  TOP w0.076: 175.92,55.83 175.92,57.36 178.05,59.49 178.87,60.31 179.41,60.31 179.9,60.8 179.9,61.19 179.9,61.19 179.9,61.24 179.71,61.42 179.71,62.48 179.76,62.65 179.76,63.06 180.14,63.44 U1.CT47
  TOP w0.102: R417.2 152.53,51 152.91,50.62 154.04,50.62 154.29,50.37 158.3,50.37 158.52,50.59 161.75,50.59 162.54,49.8 172.44,49.8 175.92,53.29
N8196332: length 46.1
  TOP w0.076: 178.22,52.94 178.22,54.41 177.65,54.97 177.65,56.94 179.5,58.78 180.23,58.78 181.8,60.35 181.8,62.61 181.71,62.82 181.71,63.75 181.67,63.78 181.67,64.06 U1.CN45
  TOP w0.109: R433.2 154.32,47.66 154.74,48.08 160.52,48.08 161.12,47.48 175.73,47.48 178.22,49.98 178.22,52.94
N8196336: length 41.8
  TOP w0.076: U1.CR47 180.55,62.83 180.54,62.83 180.54,62.56 180.59,62.51 180.59,62.18 180.39,61.98 180.39,61.7 180.58,61.51 180.58,60.41 179.84,59.67 179.15,59.67 176.74,57.26 176.74,54.26
  TOP w0.102: 176.74,54.26 176.92,54.08 176.92,52.94
  TOP w0.109: 176.92,52.94 176.92,51.92 173.87,48.87 173.33,48.87 173.33,48.87 161.4,48.87 161.39,48.87 161.38,48.87 161.12,49.14 159.36,49.14 159.26,49.23 152.9,49.23 152.54,49.59 R437.1
N8196362: length 42.9
  TOP w0.076: 177.7,52.94 177.7,54.35 177.29,54.76 177.29,57.06 179.36,59.12 180.09,59.12 181.47,60.51 181.47,62.27 U1.CN49
  TOP w0.109: 177.7,52.94 177.7,50.63 175.12,48.05 161.21,48.05 160.76,48.5 154.17,48.5 153.86,48.18 152.95,48.18 152.56,48.57 R435.2
N8196366: length 42.5
  TOP w0.075: 177.46,54.92 177.98,54.39 177.98,52.94
  TOP w0.076: 177.46,54.92 177.46,56.99 179.42,58.96 180.16,58.96 181.63,60.44 181.63,62.24 181.63,62.24 181.63,62.53 181.62,62.54 U1.CN48
  TOP w0.109: 177.98,52.94 177.98,50.24 175.5,47.76 161.15,47.76 160.63,48.29 154.48,48.29 154.14,47.94 152.35,47.94 R434.2
N8196390: length 42
  TOP w0.076: 177.13,54.58 177.13,57.13 179.29,59.29 180.02,59.29 181.3,60.57 181.3,62.1 181.15,62.25 181.15,62.43 181.18,62.54 181.18,62.88 181.15,63.05 181.18,63.16 U1.CN47
  TOP w0.102: 177.42,52.94 177.42,54.29 177.13,54.58
  TOP w0.109: R436.2 152.5,49.08 153.16,48.42 153.64,48.42 153.93,48.71 160.85,48.71 161.18,48.39 175.01,48.39 177.42,50.79 177.42,52.94
N8234227: length 10.4
  TOP w0.102: R441.1 v1(51.78,68.58)
  BOTTOM w0.102: v1(51.78,68.58) 52.06,68.86 52.06,74.63 50.16,76.54 U9.86
N8275142: length 15.7
  TOP w0.075: U1.DN17 171.57,77.71 170.44,77.71 170.26,77.89
  TOP w0.076: 170.26,77.89 170.21,77.92 arc(170.12,77.97) 170.01,77.96 169.79,77.9 arc(169.63,77.9) 169.49,77.96 arc(169.41,77.98) 169.33,77.95 arc(169.12,77.88) 168.9,77.95 arc(168.86,77.97) 168.81,77.99 arc(168.74,77.98) 168.68,77.96 arc(168.61,77.93) 168.54,77.92 v1(167.2,77.92)
  TOP w0.102: R10.1 158.14,78.32 v1(158.32,78.5)
  ART06 w0.075: 164.2,77.83 166.15,77.83 166.34,77.64 166.87,77.64 167.15,77.92 v1(167.2,77.92)
  ART06 w0.102: 164.2,77.83 163.11,78.93 162.18,78.93 161.87,78.62 160.02,78.62 159.56,78.16 158.65,78.16 v1(158.32,78.5)
N8275166: length 15.9
  TOP w0.075: v1(166.64,78.02) 166.69,77.96 167.05,78.31 167.56,78.31 167.8,78.07 168.54,78.07 arc(168.57,78.08) 168.6,78.09 arc(168.71,78.13) 168.83,78.14 arc(168.91,78.11) 168.99,78.07 arc(169.12,78.03) 169.24,78.08 arc(169.41,78.13) 169.58,78.08 arc(169.66,78.05) 169.75,78.05 169.97,78.11 arc(170.15,78.12) 170.31,78.04 arc(170.39,78.02) 170.48,78.01 U1.DP17
  TOP w0.102: v1(159.23,78.57) 158.9,78.57 158.37,79.09 R9.1
  ART06 w0.102: v1(159.23,78.57) 159.6,78.57 160.05,79.02 161.51,79.02 162.4,79.91 163.58,79.91 164.29,79.2 164.29,78.52 164.71,78.1 166.5,78.1 166.58,78.02 v1(166.64,78.02)
N8275258: length 35.6
  TOP w0.076: v1(172.21,66.64) U1.DL40
  TOP w0.102: v1(150.06,80.43) 150.09,80.46 152.07,80.46 152.58,79.95 R11.1
  ART06 w0.102: v1(150.06,80.43) 149.81,80.18 149.81,78.24 150.17,77.89 150.17,73.9 151.01,73.05 152.19,73.05 156.91,68.33 158.83,68.33 159.37,67.8 162.36,67.8 162.45,67.71 164.73,67.71 164.83,67.81 168.37,67.81 168.74,67.45 171.81,67.45 172.21,67.05 v1(172.21,66.64)
N8275262: length 36.3
  TOP w0.076: v1(171.53,66.5) U1.DP42
  TOP w0.102: R24.1 152.7,80.84 149.49,80.84 149.33,80.68 v1(149.33,80.65)
  ART06 w0.102: v1(149.33,80.65) 149.51,80.47 149.51,78.05 149.9,77.65 149.9,73.67 150.93,72.65 152.18,72.65 156.83,68.01 158.46,68.01 158.87,67.6 162.26,67.6 162.37,67.49 164.91,67.49 164.99,67.57 168.26,67.57 168.68,67.15 171.3,67.15 171.53,66.92 v1(171.53,66.5)
N8275836: length 35.7
  TOP w0.076: 174.99,54.58 175.18,54.78 175.18,57.42 178.68,60.92 178.68,61.47 178.84,61.62 178.84,62.05 178.67,62.22 178.67,62.98 178.59,63.06 178.59,64.02 U1.CV45
  TOP w0.102: 154.79,52.49 R26.2
  TOP w0.109: 174.99,54.58 172.26,51.86 163.33,51.86 162.7,52.49 154.79,52.49
N8278471: length 4.2
  BOTTOM w0.203: 221.42,100.5 U3.11
  BOTTOM w0.305: R304.2 221.17,96.89 PR77.2 221.18,97.68 PC13.1 221.18,99.31 221.42,99.55 221.42,100.5
N8293543: length 2.1
  BOTTOM w0.102: PR13.2 153.46,45.28 Q7.3
N8293743: length 2.8
  BOTTOM w0.203: Q10.3 153.27,53.99 PR71.2
N9910984: length 4.8
  BOTTOM w0.203: 220.77,100.48 220.77,101.22 220.93,101.39 U3.12
  BOTTOM w0.508: PR98.2 219.27,98.77 PC56.1 220.13,99.4 220.77,100.04 220.77,100.48
N9913025: length 5.1
  BOTTOM w0.203: U3.36 227.55,102.59 227.56,102.57
  BOTTOM w0.305: 227.56,102.57 228.66,102.57
  BOTTOM w0.508: 228.66,102.57 229.59,101.64 C465.1 229.77,102.73 PR78.2
N9913597: length 1.1
  BOTTOM w0.203: PC57.1 217.65,101.34 218.17,100.82 PR81.1
N9918536: length 3.1
  BOTTOM w0.203: 220.03,102.39 220.19,102.39 220.38,102.59 U3.15
  BOTTOM w0.305: PR59.2 219.23,102.39 PR106.1 220.03,102.39
N9920429: length 2.5
  BOTTOM w0.203: U3.17 219.67,103.39 PR112.2 219.66,103.39 PC22.1
N9920433: length 6.3
  BOTTOM w0.203: U3.18 220.49,103.79 220.31,103.97 220.31,104.6 220.16,104.75 219.29,104.75 PC22.2 218.43,104.16 217.93,104.66 PR53.1 217.87,104.66 PC23.1 PR52.2
N9920437: length 10.1
  BOTTOM w0.203: U3.16 220.3,102.99 220.19,102.88 218.23,102.88 217.93,103.18 217.24,103.18 217.08,103.34 PC23.2 PR52.1 215.93,104.09 PR51.1 PR70.1 215.86,102.88 215.86,102.49 214.82,101.46 C526.2
N9928220: length 3.4
  BOTTOM w0.203: PR6.1 220.41,105.35 220.73,105.04 220.73,104.39 220.93,104.19 U3.19
  BOTTOM w0.508: PR3.1 219.7,105.36 PR6.1
N9929119: length 1.2
  BOTTOM w0.508: PC10.2 231.3,99.16 PR15.2
N9929123: length 4.3
  BOTTOM w0.203: 226.86,100.63 226.86,100.84 226.72,100.99 U3.40
  BOTTOM w0.305: 227.91,99.58 226.86,100.63
  BOTTOM w0.508: 227.91,99.58 229.38,99.58 PR15.1
N9929346: length 1.2
  BOTTOM w0.508: PC11.2 231.15,104.11 PR4.2
N9929352: length 4.1
  BOTTOM w0.203: U3.32 226.81,104.19 227.06,104.43 227.06,104.9 227.39,105.24
  BOTTOM w0.508: PR4.1 229.53,105.46 227.62,105.46 227.39,105.24
N10068167: length 8.3
  TOP w0.203: U1.DK29 172.86,72.12 v1(172.84,72.1)
  BOTTOM w0.075: v1(172.84,72.1) 172.35,71.6 170.28,71.6 170.18,71.71 168.34,71.71 167.87,72.18 166.98,72.18 166.55,72.61 R379.2 166.54,72.61 R404.1
N10069757: length 22.3
  TOP w0.406: v2(124.83,55.19) 120.38,55.19 MQ1.6
  BOTTOM w0.203: U2.15 114.99,56.02 115.11,56.15
  BOTTOM w0.635: v2(124.83,55.19) 125.47,55.82 125.47,59.32 124.58,60.21 121.12,60.21 119.86,58.95 118.16,58.95 115.35,56.15 115.11,56.15
N10070113: length 15.4
  TOP w0.406: MQ1.1 120.61,60.43 121.41,59.63 123.62,59.63 v2(123.93,59.32)
  BOTTOM w0.203: 116.43,54.84 116.18,54.6 U2.17
  BOTTOM w0.635: v2(123.93,59.32) 123.93,58.01 122.57,56.65 119.45,56.65 117.64,54.84 116.43,54.84
N10071977: length 1.1
  BOTTOM w0.203: PR7.1 223.54,92.29 PR109.2
N10072699: length 1.1
  BOTTOM w0.203: PR8.1 224.2,91.73 PR110.2
N10073666: length 0.9
  BOTTOM w0.203: PR9.1 225.16,91.88 PR111.2
N10076660: length 0.8
  BOTTOM w0.305: PR46.1 223.65,112.9 PR79.1
N10624525: length 1.2
  TOP w0.305: C378.2 26.87,87.44 R822.2
N10624529: length 1.2
  TOP w0.305: R823.2 28.09,87.44 C376.2
N10677169: length 9.7
  TOP w0.305: D64.N 17.02,89.21 R418.2
  TOP w0.508: R418.2 15.97,89.2 13.78,91.39 11.2,91.39 v1(11.12,91.31)
  BOTTOM w0.508: R419.2 10.56,90.75 v1(11.12,91.31)
N11090699: length 6.1
  BOTTOM w0.102: U9.29 42.96,61.58 42.7,61.32 40.75,61.32 39.4,59.97 R829.1
N11090809: length 1.6
  BOTTOM w0.102: R1391.1 38.8,64.05 U9.34
N11225851: length 34.1
  TOP w0.203: U15.3 v1(157.18,92.78)
  BOTTOM w0.203: D66.N 148.01,92.25 157.19,92.25 R910.2 ; R910.2 157.32,91.84 157.71,91.45 158.24,91.45 158.78,90.92 158.78,87.63 157.33,86.18 155.24,86.18 153.11,84.05 U56.4 153.11,83.3 152.64,82.83 152.64,80.05 150.84,78.25 D71.N 150.32,76.35 D70.N ; R910.2 157.18,92.52 157.18,92.78 v1(157.18,92.78)
N11237380: length 2.4
  TOP w0.254: v1(198.63,86.49) 198.63,85.79 U1.AV2
  BOTTOM w0.254: v1(198.63,86.49) 198.25,86.49 197.84,86.91 R847.2
N11237848: length 1.2
  TOP w0.076: U1.K15 v1(212.65,79.27)
  BOTTOM w0.305: R849.2 212.54,79.17 v1(212.65,79.27)
N11238399: length 2.6
  TOP w0.075: U1.AD3 205.35,85.28 205.35,86.63 205.15,86.83 v1(205.15,87.62)
N11238403: length 0.9
  TOP w0.075: U1.AD4 205.49,83.92 v1(205.28,83.71)
N11238439: length 9.7
  TOP w0.075: v1(171.54,79.28) 171.54,79.26 171.22,78.94 U1.DP15
  ART06 w0.075: v1(171.54,79.28) 171.54,79.29 171.05,79.79 170.82,79.79 170.18,80.43 167.5,80.43 167.27,80.19 166.03,80.19 165.03,81.19 164.39,81.19 v1(164.35,81.16)
  BOTTOM w0.075: R905.1 164.64,81.28 164.52,81.16 v1(164.35,81.16)
N11238443: length 10
  TOP w0.075: R904.1 165.44,77.31 v1(165.44,77.1)
  TOP w0.076: U1.DJ17 v1(173.51,77.63)
  ART06 w0.075: v1(165.44,77.1) 165.95,77.61 166.16,77.61 166.28,77.49 167.1,77.49 167.18,77.57 168.13,77.57 168.43,77.27 173.25,77.27 173.51,77.53 v1(173.51,77.63)
N11546849: length 2.4
  BOTTOM w0.102: U9.124 56.83,65.25 57.28,64.81 57.3,64.81 R199.2
N11553427: length 0.9
  BOTTOM w0.305: PR62.1 159.33,102.2 PC63.1
N11601379: length 3.6
  BOTTOM w0.203: R862.2 142.51,90.85 143.01,91.34 Q88.1
N11605300: length 2.1
  BOTTOM w0.102: R168.2 48.16,79.16 U9.81
N11607400: length 8
  TOP w0.075: U1.DL38 172.52,67.74 172.25,67.47 170.8,67.47 170.08,66.75 170.08,66.49 169.8,66.21 168.26,66.21 167.73,66.74 R877.1
N11607850: length 2.6
  BOTTOM w0.102: R879.1 209.73,89.88 R153.2 207.58,89.88 207.35,89.65 R878.1
N11609703: length 2.6
  BOTTOM w0.102: R880.1 215.66,89.61 R881.1
  BOTTOM w0.305: R882.2 214.58,91.21 214.88,90.91 214.88,89.65 R881.1
N11610185: length 0.6
  TOP w0.076: v1(210.94,83.11) 210.66,83.28 U1.P6
N11610189: length 0.6
  TOP w0.075: U1.M6 211.25,83.52 211.63,83.14 v1(211.63,83.07)
N11610292: length 1.7
  BOTTOM w0.102: R883.1 214.03,89.57 R884.1 214.04,89.58 R885.2
N11610919: length 1.6
  BOTTOM w0.102: R888.2 R886.1 209.92,89.04 R887.1
N11611809: length 2.4
  TOP w0.102: R890.1 212.4,89.29 R891.1 212.45,89.3 R892.2
N11612380: length 0.8
  BOTTOM w0.102: R893.1 208.2,86.07 R894.2
N11614712: length 1.2
  BOTTOM w0.203: U16.3 160.62,52.01 R895.2
N11616784: length 2.8
  TOP w0.305: U51.5 148.16,79.1 148.16,79.85 147.76,80.25 R215.2 146.28,80.25 R896.2
N11617042: length 4.2
  TOP w0.203: U7.6 93.67,86.83 94.21,87.37
  TOP w0.305: 94.21,87.37 94.93,88.09 PC69.1 94.79,88.28 R898.1 94.79,89.16 R897.2
N11618128: length 2.7
  TOP w0.203: U20.12 124.95,79.61 125.28,79.28 125.28,78.53 125.85,77.96 R36.1
N11618501: length 2
  TOP w0.203: U20.6 121.92,80.39 121.64,80.1 121.64,80.05 v1(121.66,80.02)
  BOTTOM w0.305: v1(121.66,80.02) 121.49,79.84 R899.1 121.04,79.84 R900.1
N11789303: length 13.1
  TOP w0.076: U1.DL33 172.21,70.31 v1(172.21,70.31)
  TOP w0.102: R906.1 160.14,70.87 v1(160.41,70.6)
  ART06 w0.075: v1(172.21,70.31) 171.8,70.71 169.95,70.71 169.65,70.41 162.16,70.41 161.97,70.6
  ART06 w0.102: v1(160.41,70.6) 161.97,70.6
N11789370: length 3
  TOP w0.075: U1.DL34 172.22,69.47 172.22,68.4 172.27,68.35 v1(172.85,68.35)
  BOTTOM w0.075: v1(172.85,68.35) 172.85,67.56 R907.1
N11789662: length 0.5
  TOP w0.076: U1.DL17 v1(172.21,77.63)
N11789666: length 0.5
  TOP w0.075: U1.DK34 173.17,69.7 v1(172.86,69.39)
N11789670: length 0.5
  TOP w0.076: v1(171.56,70.31) 171.56,70.31 U1.DN33
N11790522: length 3.9
  TOP w0.076: U1.DJ29 173.51,72.14 v1(173.51,72.14)
  BOTTOM w0.075: v1(173.51,72.14) 173.07,72.58 170.42,72.58 R908.1
N11790600: length 19.9
  TOP w0.076: U1.DL27 172.21,73.05 v1(172.21,73.05)
  ART06 w0.102: v1(172.21,73.05) 172.21,73.44 171.48,74.17 169.58,74.17 168.78,74.97 162.45,74.97 161.7,74.22 158.8,74.22 158.49,74.53 158.49,75.08 v1(159.44,76.03)
  BOTTOM w0.102: v1(159.44,76.03) 159.34,75.93 R909.1
N11802208: length 3.3
  BOTTOM w0.102: U9.18 47.36,61.28 46.22,60.14 46.22,59.65 R911.1
N11806696: length 0.8
  BOTTOM w0.203: PR26.2 224.16,95.37 PR34.1
N11812447: length 1
  BOTTOM w0.203: PR53.2 217.98,103.6 218.5,103.6 PR112.1
N11813519: length 3.3
  BOTTOM w0.203: U3.13 220.69,101.79
  BOTTOM w0.305: 220.69,101.79 220.33,101.43 220.33,100.77 219.6,100.04 PR113.1
N11814979: length 0.9
  BOTTOM w0.305: PR25.1 223.38,107 PR28.1
N12024008: length 2.7
  BOTTOM w0.203: PR58.1 158.39,97.96 PC52.1 158.38,97.38 PR118.2 158.7,97.06 PR116.2
N12025327: length 22.4
  TOP w0.305: PR119.2 165.5,103.87 v1(165.5,104.07)
  BOTTOM w0.203: PR118.1 157.58,97.23 PR60.2 157.42,98.1 154.88,98.1 153.92,99.07 153.92,101.97 157.7,105.76 163.91,105.76 165.36,104.31 165.36,104.21 v1(165.5,104.07)
N12070219: length 10
  BOTTOM w0.305: R1388.1 44,87.19 Q48.1 43.74,89.17 40.81,89.17 39.99,88.34 Q49.3
N12070227: length 3.3
  BOTTOM w0.305: R438.2 38.91,83.48 39.24,84.28 Q49.1
N12540155: length 4
  TOP w0.305: R1392.1 91.32,110.05 D72.N 91.09,111.28 v1(91.05,111.32)
  BOTTOM w0.102: v1(91.05,111.32) 91.05,111.13 90.56,110.64 D73.N
N17228942: length 17.3
  TOP w0.305: v1(49.76,82.16) 50.09,81.84 R257.1 ; R253.1 54.31,81.84 54.31,81.85 v1(54.68,81.85) 54.93,81.85 54.94,81.84 R251.1 ; R249.1 v1(57.18,81.84) R202.1 ; R255.1 51.81,81.84 v1(52.13,82.16) 52.45,81.84 R254.1 ; v1(59.43,81.22) 59.43,81.47 R201.1
  ART06 w0.305: v1(54.68,81.85) 54.67,81.84 52.45,81.84 v1(52.13,82.16) v1(49.76,82.16)
  ART06 w0.406: v1(54.68,81.85) 57.17,81.85 v1(57.18,81.84) 57.4,82.06 58.6,82.06 v1(59.43,81.22)
  BOTTOM w0.305: Q11.3 52.13,83.54 v1(52.13,82.16)
N17229240: length 2.8
  BOTTOM w0.305: R258.2 49.99,85.73 50.35,86.09 Q11.1
N19384822: length 2.4
  BOTTOM w0.102: R245.1 U14.4 C146.2
N19848028: length 4.3
  TOP w0.102: CN10.38 99.48,64.97 99.37,64.86 99.37,63.05 98.89,62.57 R901.2
N19848541: length 7.1
  TOP w0.109: R331.2 113.63,65.24 113.72,65.15 113.72,64.71 112.95,63.94 108.89,63.94 108.61,64.22 CN10.41
N19848543: length 7.1
  TOP w0.109: CN10.43 113.04,63.72 113.94,64.62 113.94,65.03 R337.2
N19848545: length 124.2
  TOP w0.075: v1(177.64,92.03) 177.89,91.78 177.99,91.78 178.13,91.64 178.13,90.91 C277.1
  TOP w0.109: CN10.47 108.59,62.72 108.75,62.56 108.94,62.56 109.05,62.67 109.05,62.82 109.16,62.93 109.38,62.93 109.49,62.82 109.49,62.67 109.6,62.56 109.82,62.56 109.93,62.67 109.93,62.82 110.04,62.93 110.26,62.93 110.37,62.82 110.37,62.67 110.48,62.56 110.69,62.56 110.8,62.67 110.8,62.81 110.91,62.92 111.13,62.92 111.24,62.81 111.24,62.67 111.35,62.56 112.8,62.56 116.08,65.84 116.08,76.15 v1(115.88,76.35)
  ART03 w0.075: 175.38,97.44 175.39,97.43 175.41,97.43 176.08,96.77 176.08,96.72 178.02,94.77 178.02,91.94 177.93,91.86 177.81,91.86 v1(177.64,92.03)
  ART03 w0.087: 175.38,97.44 175.23,97.59 170.98,97.59 170.46,97.07 168.2,97.07 167.32,96.18 166.25,96.18 165.61,95.54 164.12,95.54 163.12,96.53 160.67,96.53 159.73,97.48 153.6,97.48 151.52,95.39 132.88,95.39 132.07,96.2 128.77,96.2 127.37,97.6 124.17,97.6 123.47,96.89 118.79,96.89 110.85,88.96 110.85,77.46 109.82,76.43 109.82,75.14 110.19,74.77 115.39,74.77 116.3,75.68 116.3,75.93 v1(115.88,76.35)
N19848547: length 124.2
  TOP w0.075: C278.1 177.98,90.97 177.98,91.58 177.93,91.63 177.84,91.63 v1(177.64,91.42)
  TOP w0.109: CN10.49 108.61,62.22 108.74,62.35 112.89,62.35 116.29,65.74 116.29,76.15 v1(116.49,76.35)
  ART03 w0.075: 175.51,97.57 175.52,97.56 175.52,97.54 176.23,96.83 176.23,96.78 178.17,94.83 178.17,91.88 177.72,91.42 v1(177.64,91.42)
  ART03 w0.087: v1(116.49,76.35) 116.49,75.61 115.47,74.59 110.11,74.59 109.63,75.07 109.63,76.5 110.67,77.54 110.67,89.04 118.71,97.08 123.4,97.08 124.1,97.78 127.45,97.78 128.84,96.38 132.14,96.38 132.95,95.57 151.44,95.57 153.53,97.66 157.71,97.66 157.73,97.64 159.82,97.64 160.74,96.72 163.2,96.72 164.19,95.72 165.54,95.72 166.18,96.36 167.24,96.36 168.11,97.23 170.39,97.23 170.94,97.77 175.31,97.77 175.51,97.57
N19848677: length 1.2
  TOP w0.102: R526.1 93.83,62.63 U40.2
N19848727: length 4.2
  TOP w0.102: R525.2 96.52,62.15 96.68,61.98 U40.4 96.95,61.97 CN10.50
N20170654: length 1.6
  TOP w0.102: Q72.1 230.62,18.2 D25.N
N20170656: length 0.8
  TOP w0.102: R559.1 231.57,21.13 C642.1
N20881703: length 5.3
  TOP w0.102: Q13.3 49.72,73.43 51.24,71.91 Q12.1 51.24,71.03 R115.2
N20893807: length 2.3
  TOP w0.109: R622.2 146.81,56.69 147.48,56.02 Q15.2 148.42,56.02 R619.2
N20893813: length 1.5
  TOP w0.109: Q15.1 148.28,58.28 R624.1
N20893917: length 1.7
  TOP w0.109: Q18.1 150.7,52.62 R629.1
N20893926: length 2.1
  TOP w0.109: R628.2 147.5,53.52 Q18.3
N20896085: length 5.3
  TOP w0.076: U1.CN42 v1(182.15,65.81)
  BOTTOM w0.075: R665.2 180.46,62.44 181,62.97 181.51,62.97 181.67,63.14 181.67,65.34 v1(182.15,65.81)
N20896142: length 5.4
  TOP w0.076: v1(182.14,65.17) 182.14,65.17 U1.CN43
  BOTTOM w0.075: v1(182.14,65.17) 182.41,64.9 182.41,63.56 181.62,62.77 181.14,62.77 R664.2
N20896439: length 3.7
  TOP w0.076: U1.DU24 169.41,74.08 168.8,74.08 168.5,73.93 168.44,73.93 167.83,73.32 v1(167.83,72.75)
  BOTTOM w0.075: v1(167.83,72.75) 168.23,73.15 R680.1
N20896443: length 3.5
  TOP w0.076: U1.DV24 168.83,74.29 168.64,74.19 168.54,74.14 168.32,74.14 167.42,73.24 167.02,73.24 R679.1
N20896586: length 5.3
  TOP w0.075: 185.6,59.46 185.6,58.45 R649.2
  TOP w0.076: 185.6,59.46 185.6,60.91 185.46,61.05 185.46,62.72 U1.CF48
N20896653: length 11.5
  TOP w0.076: v1(180.32,54.66) 180.33,54.65 181.2,54.65 182.39,55.85 182.39,56.62 183.47,57.7 183.47,59.19 184,59.72 184,61.09 184.18,61.28 184.18,62.43 U1.CH48
  BOTTOM w0.102: v1(180.32,54.66) 179.43,54.66 R650.1
N20896704: length 10.3
  TOP w0.076: U1.CH49 184.02,62.27 184.02,61.35 183.84,61.16 183.84,59.79 183.31,59.26 183.31,57.77 182.21,56.67 182.21,56.11 181.37,55.27 180.23,55.27 v1(180.23,55.27)
  BOTTOM w0.075: v1(180.23,55.27) 180.38,55.27 180.53,55.42 R655.1
N20910631: length 1.3
  BOTTOM w0.508: D3.P 179.87,44.67 R222.1
N20947983: length 3
  BOTTOM w0.305: R187.1 R225.2 U52.2
N20948027: length 2.6
  BOTTOM w0.305: R185.1 R183.1 213.03,12.01 213.51,12.49 U52.8
N20948057: length 1.7
  BOTTOM w0.305: U52.7 R182.2
N20949015: length 2
  TOP w0.305: U51.7 144.51,78.59 R186.1 144.34,78.75 R188.1
N20949239: length 2.8
  TOP w0.305: R191.1 144.3,79.8 R220.2 144.96,79.09 U51.6
N20954657: length 2.7
  TOP w0.508: Q9.4 182.6,112.49 PR48.2 182.48,111.8 PR50.2
N20954968: length 2.6
  TOP w0.508: PR22.2 191.19,114 PR16.2 191.38,113.27 190.92,112.81 Q6.4
N20954970: length 3
  TOP w0.508: PR1.2 198.14,105.74 Q5.4 197.84,107.33 PR5.2
N20955067: length 2.1
  TOP w0.508: Q8.4 178.06,110.47 PR44.2 179.13,110.53 PR43.2
N20955215: length 1.1
  TOP w0.508: PC7.2 196.63,113.77 PR14.1
N20955669: length 2.7
  TOP w0.508: PR80.2 213.33,113.45 PR74.2 212.76,111.87 Q32.4
N20955799: length 1.1
  TOP w0.508: PR73.1 208.31,103.06 PC38.2
N20955838: length 2.7
  TOP w0.508: PR65.2 210.97,113.39 210.49,112.92 PR67.2 210.65,112.45 Q29.4
N20957599: length 0.8
  BOTTOM w0.203: PR33.1 223.12,95.38 PR21.2
N20957638: length 0.8
  BOTTOM w0.203: PR35.1 225.16,96.23 PR24.2
N20959230: length 1.9
  BOTTOM w0.203: U16.6 164.14,52.01 164.36,52.23 164.36,52.93 C215.2
N20959572: length 1
  TOP w0.203: C10.2 160.52,92.78 U15.6
N20962294: length 2.7
  TOP w0.305: Q68.4 91.51,71.42 R789.1 C225.2
N20962380: length 2.2
  BOTTOM w0.305: C224.2 R465.1 121.11,69.51 Q56.4
N20962423: length 1.3
  BOTTOM w0.305: R790.2 119.17,67.86 Q71.1
N20962724: length 1.3
  BOTTOM w0.305: R794.1 144.23,57.69 Q78.3
N20962834: length 1.5
  TOP w0.305: Q80.3 R796.1
N20962840: length 1.7
  BOTTOM w0.508: R797.1 127.31,65.29 Q81.3
N20962846: length 1.3
  BOTTOM w0.305: Q83.3 108.2,54.59 R799.1
N20962856: length 1.7
  TOP w0.508: Q85.3 231.65,98.36 R801.1
N20962894: length 1.5
  BOTTOM w0.305: R800.1 151.34,87.3 Q84.3
N20963383: length 0.9
  TOP w0.203: C396.2 147.07,70.65 U55.6
N20968842: length 8.9
  TOP w0.305: R171.1 92.86,113.66 v1(93.84,114.64)
  BOTTOM w0.305: v1(93.84,114.64) 95.52,112.96 Q30.3
N21033241: length 7.4
  TOP w0.109: U23.2 34.83,65.29 34.45,64.91 34.45,64.53 34.74,64.23 34.74,62.65 34.61,62.51 Q44.3 36.52,61.7 R371.2 R385.2
N21033281: length 5.1
  TOP w0.109: R390.1 36.74,57.48 34.56,55.3 Q41.1
N21033871: length 3.8
  TOP w0.102: R386.2 32.6,59.7 Q44.1 33.66,58.8 34.65,57.8 Q41.3
N21324281: length 2.3
  TOP w0.075: U1.DW33 167.94,69.98 R78.1
N22193769: length 1.4
  BOTTOM w0.203: C131.2 113.79,51.55 U2.4
N22193795: length 2.1
  BOTTOM w0.203: 116.48,54.2 U2.18
  BOTTOM w0.406: 116.48,54.2 117.21,54.2 R1.1
N22193823: length 1.4
  BOTTOM w0.305: R127.1 109.28,50.85 C197.2
N22193910: length 3.5
  BOTTOM w0.203: Q4.3 107.68,51.19 108.44,51.96 R117.2
N22193984: length 2.2
  BOTTOM w0.203: R120.1 R112.2 112.07,54.29 112.16,54.2 U2.8
N22194036: length 1.6
  BOTTOM w0.203: U2.9 112.23,54.6 111.77,55.06 R109.1
N22194247: length 2.7
  BOTTOM w0.203: PR92.1 112.43,57.11 R56.1 112.62,56.6 113.39,55.84 U2.11
N22194263: length 1.5
  BOTTOM w0.203: R55.2 114.55,56.59 114.19,56.23 U2.13
N22194449: length 3
  BOTTOM w0.406: C130.1 120.47,55.27 R1.2
N22197677: length 2.1
  TOP w0.203: D6.3 88.5,89.85 C24.2
N22197683: length 10.9
  TOP w0.305: D5.2 81.79,86.84 81.29,87.34 81.29,91.46 82.44,92.61 C28.1 83.83,92.61 84.32,92.11 D6.1
N22197720: length 2.7
  TOP w0.203: C23.2 87.49,88.82 86.46,87.79 D5.3
N22197814: length 2.3
  TOP w0.203: C333.2 121.98,78.01 123.14,79.17 U20.9
N22197843: length 3.4
  TOP w0.203: C332.1 R39.2 ; C332.1 123.51,79.04 123.59,79.12 U20.10 ; C332.1 R40.1
N22198022: length 5.9
  TOP w0.305: 127.75,81.13 127.75,77.42 127.14,76.81 C31.2 ; 127.75,81.13 127.99,81.37 ; 127.75,81.13 127.75,81.18 ; 127.75,81.18 127.75,81.4 ; 127.75,81.18 127.57,81.36
N22198056: length 1.2
  TOP w0.305: R38.1 123.51,76.13 C332.2
N22198095: length 1.4
  TOP w0.203: 125.25,80.39 U20.1
  TOP w0.406: 125.25,80.39 126.09,80.39 R35.1
N22198097: length 1.4
  TOP w0.305: C31.1 126.64,78.48 R35.2
N34621689: length 1.8
  TOP w0.305: R200.2 121.68,114.19 Q36.3
N34621695: length 1.1
  TOP w0.305: LED2.2 124.07,114.19 R200.1
N77955914: length 3.5
  TOP w0.102: U25.15 31.99,83.57 32.11,83.68 32.39,83.68 33.89,85.19 TP58.1
N77955916: length 3.6
  TOP w0.102: U25.17 31.19,83.72 31.68,84.21 32.29,84.21 32.78,84.7 32.78,85.69 TP57.1
N77955917: length 2.5
  TOP w0.102: TP56.1 31.85,84.46 31.53,84.46 30.79,83.72 U25.18
N118215190: length 0.8
  BOTTOM w0.203: PR49.1 216.62,109.76 PR45.1
N780067955: length 1.9
  BOTTOM w0.102: U9.111 56.19,70.45 56.82,69.82 TP63.1

## Copper pours and planes (outline as drawn)
+V1.8A_PCH on BOTTOM (solid shape): outline of 537 points within 167.14,75.75 175.77,80.15
+V1.8A_PCH on ART06 (solid shape): outline of 1168 points within 174.32,68.65 178.14,78.84
+V1.8U_2.5U_MEM on TOP (solid shape): 226.6,13.44 226.6,10.82 226.2,10.41 225.38,10.41 225.06,10.74 225.06,13.49 225.22,13.66 226.39,13.66
+V1.8U_2.5U_MEM on TOP (solid shape): 227.55,25.1 227.63,25.11 227.96,25.11 228.06,25.01 228.07,25 228.08,24.98 228.08,23.6 228.07,23.58 228.06,23.57 227.42,22.93 225.17,22.93 225.06,23.03 225.06,25.05 225.13,25.11 227.46,25.11
+V1.8U_2.5U_MEM on BOTTOM (solid shape): 229,24.09 229,23.22 229.23,22.99 229.23,21.23 229.32,21.15 229.32,21.02 229.57,20.77 229.57,18.85 229.79,18.63 229.79,16.79 229.48,16.26 230.09,16.15 230.2,16.18 230.26,16.08 230.26,14.36 230.26,14.34 230.24,14.32 229.17,12.92 229.22,11.16 229.22,9.69 229.21,9.67 229.19,9.65 228.89,9.4 228.68,9.06 228.66,9.04 228.63,9.03 224.75,9.03 224.3,8.58 224.29,8.57 223.97,8.25 219.29,8.25 219.19,8.16 218.74,8.16 218.51,8.39 218.51,10.4 218.65,10.54 223.41,10.54 224.1,11.24 226.09,11.24 227.51,12.65 227.51,14.42 227.53,14.44 227.53,15.14 228.1,15.71 228.1,15.82 228.22,15.95 228.22,20.04 228.1,20.17 228.1,20.24 226.93,21.4 226.93,24.81 227.17,25.04 228.05,25.04
+V1P05A on TOP (solid shape): 190.09,91.92 190.09,90.59 189.74,90.24 188.98,90.24 188.52,90.71 188.52,91.98 188.66,92.13 189.88,92.13
+V1P05A on TOP (solid shape): 158.11,94.65 158.11,93.18 158.06,93.14 157.31,93.14 157.3,93.14 156.82,92.9 157.07,92.42 157.08,92.42 157.26,92.24 157.26,90.38 156.94,90.06 156.88,90.06 156.88,90 156.84,89.97 156.84,89.38 156.68,89.22 155.24,89.22 155.15,89.12 155.12,89.12 155.12,89.09 155.07,89.04 155.07,88.73 154.65,88.31 153.68,88.31 153.35,88.64 153.35,90.83 153.65,91.13 155.23,91.13 155.41,91.31 155.41,91.41 155.42,91.44 155.46,91.46 155.61,91.46 155.87,91.72 155.87,91.8 155.87,92.52 155.87,92.52 155.87,93.32 155.82,93.32 155.41,93.73 155.41,94.58 155.67,94.85 156.27,94.85 156.29,94.87 157.89,94.87
+V1P05A on PWR05 (solid shape): outline of 229 points within 154.67,89.29 190.16,100.09
+V1P05A_E on TOP (solid shape): outline of 94 points within 148.36,85.23 155.83,94.63
+V1P05S_VCCST on TOP (solid shape): 160.84,94.82 160.9,94.82 160.97,94.75 162.29,94.75 162.3,94.74 163.03,94.74 163.12,94.65 163.12,93.68 162.42,92.98 162.15,92.98 162.1,92.92 161.29,92.92 161.11,93.11 160.7,93.11 160.69,93.11 159.46,93.11 159.38,93.19 159.38,94.89 159.46,94.97 160.69,94.97
+V1P05S_VCCSTG on TOP (solid shape): 162.61,92.45 162.61,91.99 162.73,91.87 162.87,91.87 162.99,91.86 163.12,91.74 163.12,91.17 161.24,89.28 161.23,89.28 159.54,89.28 159.47,89.21 158.26,89.21 158.09,89.39 158.09,89.52 158.09,89.53 158.13,89.68 158.09,89.83 158.09,89.84 158.09,90.3 158.1,90.32 158.12,90.33 158.27,90.48 158.32,90.68 158.32,90.71 158.51,90.9 159.55,90.9 159.61,90.84 159.61,90.57 159.69,90.49 159.69,90.43 159.75,90.43 159.79,90.39 160.15,90.39 160.22,90.32 161.07,90.32 161.19,90.44 161.28,90.44 161.28,90.53 161.32,90.56 161.32,91.31 161.09,91.53 161.09,92.33 161.32,92.55 162.51,92.55
+V1P8A on TOP (solid shape): 154.22,76.11 154.22,74.74 153.79,74.31 153.41,74.31 151.76,72.66 148.69,72.66 148.27,73.08 147.5,73.08 147.42,73.16 147.42,73.8 147.53,73.91 147.53,76.05 147.82,76.35 153.99,76.35
+V1P8A on TOP (solid shape): 189.86,87.4 189.86,87.39 189.86,87.19 189.51,86.84 189.49,86.84 189.28,86.76 189.17,86.56 189.16,86.55 188.95,86.34 188.95,86.28 188.95,85.59 188.68,85.31 188.67,85.31 188.51,85.31 188.44,85.37 188.44,86.46 189.48,87.5 189.76,87.5
+V1P8A on BOTTOM (solid shape): 194.6,82.62 194.6,82.01 194.55,81.95 194,81.95 193.84,81.8 193.84,81.13 193.74,81.04 191.75,81.04 191.66,81.12 191.66,81.83 192.22,82.39 192.22,82.54 192.35,82.67 194.55,82.67
+V1P8A on BOTTOM (solid shape): outline of 733 points within 150.65,72.9 166.81,80.84
+V1P8A on ART06 (solid shape): 167.01,79.13 167.14,79.08 167.27,79.09 168.22,79.09 168.66,78.65 170.03,78.65 170.22,78.46 170.22,78.25 169.79,77.83 168.15,77.83 167.49,78.49 166.04,78.49 166.02,78.47 166.01,78.47 165.84,78.3 165.27,78.3 165.14,78.43 165.14,79.02 165.25,79.13
+V1P8A on ART06 (solid shape): 191.23,82.5 191.24,82.47 191.23,82.46 191.35,82.1 191.73,82.09 191.85,82.09 192.45,82.69 194.42,82.69 194.51,82.59 194.51,82.01 194.42,81.92 192.79,81.92 192.19,81.31 191.02,81.31 190.76,81.58 189.85,81.58 189.66,81.77 189.66,82.11 190.43,82.88 190.85,82.88
+V1P8S on TOP (solid shape): 148.84,71.56 148.84,69.57 148.34,69.07 147.46,69.07 147.42,69.08 147.41,69.12 147.41,71.64 147.51,71.74 148.65,71.74
+V3.3_LAN on BOTTOM (solid shape): 70.18,74.18 70.18,72.52 70.53,72.17 70.53,72.09 70.46,72.02 69.53,72.02 68.93,72.62 68.93,73.57 69.61,74.25 70.12,74.25
+V3.3_LAN on BOTTOM (solid shape): 70.78,61.49 70.78,60.42 71.09,60.11 73.12,60.11 73.32,59.91 73.32,57.63 73.22,57.53 69.7,57.53 68.59,58.64 68.59,61.41 68.82,61.65 70.63,61.65
+V3.3_WIFI on TOP (solid shape): 130.47,91.04 133.89,91.04 133.98,90.96 133.98,90.26 133.69,89.97 127.15,89.97 126.51,90.61 126.51,91.15 126.72,91.36 130.15,91.36
+V3.3_WIFI on TOP (solid shape): 131.71,110.13 133.16,110.13 133.99,109.3 133.99,108.61 134.04,108.56 134.04,107.78 133.97,107.71 131.53,107.71 130.94,108.3 126.9,108.3 124.04,105.44 124.04,102.61 124.62,102.02 124.62,98.94 124.11,98.43 121.98,98.43 121.7,98.71 121.7,101.14 121.46,101.38 121.46,106.69 124.99,110.21 131.63,110.21
+V3.3_WIFI on BOTTOM (solid shape): 123.3,99.28 123.3,97.91 124.4,96.82 124.45,96.73 124.52,96.67 124.57,96.62 124.64,96.57 124.84,96.37 124.84,95.1 124.77,94.88 124.84,94.65 124.84,92.22 124.85,92.2 124.85,92.19 124.96,91.89 125.26,91.78 125.27,91.78 125.29,91.77 125.31,91.75 128.03,91.75 128.22,91.57 128.22,90.57 127.99,90.35 123.66,90.35 123.17,90.83 123.17,96.06 121.56,97.67 121.56,99.19 121.7,99.33 123.25,99.33
+V3.3A_PCH on BOTTOM (solid shape): outline of 1083 points within 168.25,69.36 178,76.69
+V3.3S on TOP (solid shape): 52.98,13.78 52.98,12.8 52.81,12.63 51.73,12.63 51.54,12.83 51.54,13.95 51.66,14.07 52.68,14.07
+V3.3S on TOP (solid shape): 37.38,70.64 37.38,68.94 37.39,68.93 37.39,65.57 37.01,65.18 36.39,65.18 36.02,65.56 36.02,70.71 36.08,70.78 37.24,70.78
+V3.3S on TOP (solid shape): 233.5,53.77 233.5,52.74 233.44,52.68 232.86,52.68 232.82,52.65 232.77,52.65 232.77,52.59 232.43,52.25 232.43,52.25 232,52.68 231.86,52.68 231.76,52.79 231.76,53.76 231.92,53.92 233.35,53.92
+V3.3S on TOP (solid shape): 99.77,76.78 99.77,75.91 99.57,75.72 99.19,75.72 99.03,75.56 99.03,75.28 98.85,75.1 98.41,75.1 98.32,75.18 98.32,75.55 98.27,75.6 98.26,75.6 98.01,75.85 95.82,75.85 95.72,75.95 95.72,77.19 95.93,77.41 99.14,77.41
+V3.3S on TOP (solid shape): 145.51,68.82 145.61,68.82 146.16,68.28 152.01,68.28 152.83,67.46 152.83,67.46 153.35,66.94 153.35,66.08 153.04,65.77 146.41,65.77 145.57,66.61 149.73,66.61 149.73,66.55 149.74,66.5 149.76,66.45 149.79,66.4 149.82,66.35 149.86,66.32 149.91,66.28 149.96,66.26 150.01,66.24 150.06,66.23 150.12,66.23 150.17,66.23 150.23,66.25 150.28,66.27 150.33,66.3 150.37,66.33 150.4,66.37 150.44,66.42 150.46,66.47 150.47,66.52 150.48,66.58 150.48,66.63 150.47,66.69 150.46,66.74 150.44,66.79 150.4,66.84 150.37,66.88 150.33,66.91 150.28,66.94 150.23,66.96 150.17,66.98 150.12,66.98 150.06,66.98 150.01,66.97 149.96,66.95 149.91,66.93 149.86,66.9 149.82,66.86 149.79,66.81 149.76,66.77 149.74,66.72 149.73,66.66 149.73,66.61 145.57,66.61 142.3,69.88 132.84,69.88 131.03,68.07 129.68,68.07 129.56,68.18 129.56,70.05 130.91,71.4 142.93,71.4
+V3.3S on BOTTOM (solid shape): 125.34,69.79 125.34,64.95 125.02,64.63 121.75,64.63 121.55,64.83 121.55,69.84 121.6,69.89 125.24,69.89
+V3.3S on BOTTOM (solid shape): 153.64,66.57 153.64,65.34 153.35,65.05 152.54,65.05 151.81,65.77 151.81,66.58 152.05,66.82 153.4,66.82
+V3.3S on BOTTOM (solid shape): 60.45,18.68 60.45,18.4 60.59,18.26 63.19,18.26 63.46,17.99 63.46,15.97 63.31,15.81 59.89,15.81 59.8,15.91 59.8,17.29 59.5,17.59 59.14,17.59 59.01,17.71 59.01,18.77 59.09,18.85 60.28,18.85
+V3.3S on BOTTOM (solid shape): outline of 86 points within 227.57,56.62 233.94,67.76
+V3.3S on ART03 (solid shape): outline of 287 points within 61.1,14.01 70.47,47.56
+V3.3S on PWR05 (solid shape): outline of 2846 points within 64.97,46.4 126.09,68.77

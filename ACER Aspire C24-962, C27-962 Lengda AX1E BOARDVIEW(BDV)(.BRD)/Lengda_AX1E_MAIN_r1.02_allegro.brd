# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ<31>: length 52.7
  TOP w0.109: U1.BW43 188.73,65.23 188.75,65.17 v1(188.77,65.16) ; CN11.29 166.22,24.05 v1(166.22,25.34)
  ART06 w0.087: v1(188.77,65.16) 188.61,65 188.61,63.53 184.88,59.8 184.47,59.8 183.52,58.86 182.31,58.86 179.41,55.95 179.41,54.14 178.99,53.73 178.99,51.76 165.46,38.23 165.46,27.17 165.73,26.9 165.73,25.59 165.97,25.34 v1(166.22,25.34)
M_A_DQ<32>: length 54.3
  TOP w0.076: 198.04,54.62 197.98,54.69 197.98,60.92 197.41,61.49 197.41,62.51 197.5,62.6 197.5,62.76 197.56,62.85 197.57,62.86 U1.AY48
  TOP w0.109: CN11.170 203.47,30.54 203.32,30.38 v1(202.97,30.38)
  TOP w0.135: 198.04,54.62 198.04,53.66 198.62,53.08 199,53.08 v1(199.18,53.26)
  ART06 w0.087: v1(199.18,53.26) 199.43,53.26 199.56,53.13 199.56,51.92 200.99,50.5 200.99,50.22 203.44,47.77 207.61,47.77 210.84,44.54 210.84,38.73 207.56,35.45 207.56,34.97 206.42,33.84 205.94,33.84 203.8,31.69 203.8,31.48 203.71,31.39 203.52,31.39 203.43,31.3 203.43,31.13 203.52,31.04 203.71,31.04 203.8,30.96 203.8,27.47 203.66,27.33 203.38,27.33 203.26,27.44 203.26,28.82 203.35,28.9 203.35,30.28 203.25,30.38 v1(202.97,30.38)
M_A_DQ<33>: length 55.1
  TOP w0.076: U1.AY47 197.66,63.42 197.89,63.19 197.89,62.92 197.88,62.91 197.88,62.87 197.87,62.81 197.87,62.66 197.88,62.57 197.88,62.53 197.89,62.53 197.9,62.45 197.9,62.23 197.76,62.1 197.76,61.61 197.82,61.55 198.31,61.06 198.31,55.46 199.31,54.46 v1(200.46,54.46)
  TOP w0.109: CN11.187 207.79,24.12 207.79,25.48 v1(207.35,25.93)
  ART06 w0.087: v1(207.35,25.93) 207.07,25.65 206.91,25.65 206.7,25.86 206.7,28.38 206.51,28.57 206.39,28.57 206.05,28.24 205.93,28.24 205.8,28.36 205.8,28.48 206.14,28.82 206.14,28.94 205.93,29.15 205.93,31.45 206.5,32.02 207.2,32.02 209.45,34.27 209.45,34.97 212.51,38.03 212.51,45.41 208.45,49.46 204.26,49.46 202.45,51.28 201.83,51.28 200.93,52.17 200.93,53.99 v1(200.46,54.46)
M_A_DQ<34>: length 53.7
  TOP w0.076: 198.29,54.93 198.14,55.08 198.14,60.99 197.65,61.48 197.58,61.56 197.58,62.31 U1.AY49
  TOP w0.109: v1(202.97,29.21) 203.38,29.21 204.47,30.3 CN11.174
  TOP w0.135: 198.29,54.93 v1(199.2,54.02)
  ART06 w0.087: v1(202.97,29.21) 202.97,27.21 203.23,26.96 203.75,26.96 204.09,27.29 204.09,31.57 206,33.49 206.56,33.49 207.94,34.87 207.94,35.42 211.13,38.61 211.13,44.77 207.84,48.06 203.56,48.06 201.28,50.34 201.28,50.5 199.73,52.04 199.73,53.21 199.35,53.6 199.35,53.87 v1(199.2,54.02)
M_A_DQ<35>: length 53.9
  TOP w0.076: v1(199.47,54.98) 198.47,55.98 198.47,61.13 197.94,61.66 197.94,62.04 198.07,62.17 198.07,62.38 198.05,62.6 198.05,62.86 198.06,62.91 198.06,63.22 198,63.37 198,64.15 198.18,64.33 U1.AU45
  TOP w0.109: CN11.173 204.22,24.05 204.22,25.43 v1(204.72,25.93)
  ART06 w0.087: v1(199.47,54.98) 199.57,54.89 199.57,53.62 200.05,53.14 200.05,52.01 203.71,48.36 207.98,48.36 211.42,44.92 211.42,38.49 208.31,35.38 208.31,34.7 206.77,33.16 206.09,33.16 204.38,31.45 204.38,27.12 203.81,26.54 203.81,26.08 204,25.89 204.69,25.89 v1(204.72,25.93)
M_A_DQ<36>: length 56
  TOP w0.076: U1.AY45 197.42,64.09 197.42,63.9 197.34,63.82 197.34,62.67 197.23,62.56 197.23,61.44 197.81,60.85 197.81,54.46
  TOP w0.109: CN11.169 203.22,24.05 203.22,26.12 202.03,27.32 v1(201.86,27.32)
  TOP w0.135: v1(199.21,51.94) 198.66,52.49 198.66,52.69 197.81,53.54 197.81,54.46
  ART06 w0.087: v1(201.86,27.32) 202.2,26.98 202.45,26.98 202.63,27.16 202.63,28.31 202.41,28.52 201.99,28.52 201.91,28.6 201.91,28.77 202.01,28.87 202.41,28.87 202.5,28.96 202.5,29.13 202.41,29.22 201.99,29.22 201.91,29.29 201.91,29.47 202.01,29.56 202.41,29.56 202.5,29.65 202.5,31.11 202.98,31.59 203.28,31.59 205.85,34.16 206.23,34.16 207.17,35.1 207.17,35.48 210.55,38.85 210.55,44.4 207.53,47.42 203.38,47.42 200.68,50.11 200.68,50.52 199.26,51.94 v1(199.21,51.94)
M_A_DQ<37>: length 54
  TOP w0.076: v1(200.47,56.99) 200.47,57.02 199.67,57.83 199.66,57.83 199.44,58.05 199.44,58.06 199.35,58.15 199.35,62.52 199.22,62.79 199.22,63.38 U1.AU47
  TOP w0.109: CN11.186 207.47,29.72 v1(206.97,29.21)
  ART06 w0.087: v1(206.97,29.21) 207.08,29.21 208.09,28.21 208.28,28.21 208.44,28.37 208.44,28.56 207.78,29.22 207.78,29.74 207.69,29.83 207.4,29.83 207.32,29.91 207.32,30.09 207.4,30.17 207.69,30.17 207.78,30.26 207.78,30.43 207.69,30.52 207.4,30.52 207.32,30.61 207.32,30.78 207.4,30.87 207.69,30.87 207.78,30.95 207.78,31.23 213.38,36.83 213.38,45.77 208.81,50.33 204.69,50.33 204.02,51 203.67,51 202.73,51.94 201.96,51.94 201.47,52.43 201.47,56.67 201.15,56.99 v1(200.47,56.99)
M_A_DQ<38>: length 52.9
  TOP w0.076: v1(200.47,56.35) 200.17,56.35 200.04,56.48 200.04,57.22 199.6,57.66 199.59,57.66 199.27,57.98 199.27,57.99 199.19,58.07 199.19,62.44 199.17,62.48 199.15,62.51 199.15,62.53 199.11,62.56 199.06,62.7 199.06,62.73 U1.AU48
  TOP w0.109: CN11.182 206.47,30.7 206.8,30.37 v1(206.97,30.37)
  ART06 w0.087: v1(206.97,30.37) 206.68,30.37 206.51,30.54 206.51,31.11 206.83,31.42 207.56,31.42 210.57,34.43 210.57,34.55 210.28,34.84 210.28,34.96 210.41,35.08 210.53,35.08 210.81,34.8 210.93,34.8 211.08,34.94 211.08,35.2 210.85,35.43 210.85,35.55 210.97,35.67 211.09,35.67 211.32,35.45 211.44,35.45 211.57,35.57 211.57,35.69 211.34,35.92 211.34,36.04 211.46,36.16 211.58,36.16 211.81,35.94 211.93,35.94 212.06,36.06 212.06,36.18 211.83,36.41 211.83,36.53 211.95,36.65 212.07,36.65 212.3,36.43 212.42,36.43 212.55,36.55 212.55,36.67 212.32,36.9 212.32,37.02 212.44,37.15 212.56,37.15 212.79,36.92 212.91,36.92 213.04,37.04 213.04,37.16 212.9,37.3 212.9,37.6 213.09,37.79 213.09,45.65 208.69,50.04 204.57,50.04 203.8,50.81 203.58,50.81 202.64,51.74 201.89,51.74 201.29,52.35 201.29,54.98 201.21,55.07 201.15,55.07 201.06,55.16 201.06,55.33 201.15,55.42 201.21,55.42 201.29,55.5 201.29,55.68 201.21,55.76 201.15,55.76 201.06,55.85 201.06,56.02 201.15,56.11 201.21,56.11 201.29,56.2 201.29,56.54 201.15,56.69 200.8,56.69 v1(200.47,56.35)
M_A_DQ<39>: length 52.3
  TOP w0.076: v1(200.47,55.08) 199.87,55.68 199.87,56.72 199.87,56.72 199.87,57.16 199.53,57.5 199.52,57.5 199.11,57.91 199.11,57.92 199.03,58 199.03,62.28 U1.AU49
  TOP w0.109: CN11.183 206.72,24.05 206.72,26.47 v1(207.35,27.09)
  ART06 w0.087: v1(200.47,55.08) 201.11,54.44 201.11,52.63 201.13,52.61 201.13,52.28 201.89,51.52 202.55,51.52 203.5,50.57 203.63,50.57 204.45,49.75 208.57,49.75 212.8,45.53 212.8,37.91 209.78,34.89 209.78,34.06 207.44,31.72 206.61,31.72 206.22,31.33 206.22,29.27 206.99,28.5 206.99,28.31 207.08,28.22 207.65,28.22 207.74,28.13 207.74,27.96 207.65,27.87 207.08,27.87 206.99,27.79 206.99,27.19 207.09,27.09 v1(207.35,27.09)
M_A_DQ<40>: length 64.2
  TOP w0.109: U1.AY42 v1(197.97,65.82) ; v1(217.68,27.35) 217.89,27.35 218.22,27.02 218.22,24.05 CN11.229
  ART06 w0.087: v1(197.97,65.82) 197.97,65.7 198.43,65.24 198.43,62.62 201.15,59.9 209.83,59.9 211.01,58.71 216.56,58.71 217.28,58 217.28,51.8 217.52,51.56 217.52,50.34 219.43,48.43 219.43,34.26 216.07,30.9 216.07,29.09 216.23,28.93 216.41,28.93 216.76,29.28 216.88,29.28 217,29.16 217,29.03 216.56,28.59 216.56,28.47 216.68,28.35 216.8,28.35 217.13,28.67 217.25,28.67 217.37,28.55 217.37,28.43 217.05,28.1 217.05,27.98 v1(217.68,27.35)
M_A_DQ<41>: length 64.9
  TOP w0.109: v1(197.95,67.73) U1.AY38 ; v1(217.55,30.37) 217.33,30.37 216.97,30.72 CN11.224
  ART06 w0.087: v1(217.55,30.37) 217.16,30.76 217.16,31.13 220.01,33.98 220.01,48.68 218.56,50.13 218.56,57.86 216.67,59.74 215.35,59.74 215.26,59.83 215.26,60.16 215.18,60.24 215.01,60.24 214.91,60.15 214.91,59.83 214.83,59.74 214.65,59.74 214.57,59.83 214.57,60.23 214.48,60.32 214.31,60.32 214.22,60.23 214.22,59.83 214.13,59.74 213.96,59.74 213.87,59.83 213.87,60.23 213.79,60.32 213.62,60.32 213.53,60.23 213.53,59.83 213.44,59.74 213.27,59.74 213.18,59.83 213.18,60.23 213.1,60.32 212.92,60.32 212.84,60.23 212.84,59.83 212.75,59.74 212.58,59.74 212.49,59.83 212.49,60.23 212.4,60.32 212.23,60.32 212.14,60.23 212.14,59.83 212.06,59.74 211.88,59.74 211.8,59.83 211.8,60.23 211.71,60.32 211.54,60.32 211.45,60.23 211.45,59.83 211.36,59.74 210.87,59.74 210.29,60.32 201.21,60.32 198.77,62.76 198.77,65.42 198.5,65.69 198.5,67.19 v1(197.95,67.73)
M_A_DQ<42>: length 63.6
  TOP w0.109: U1.AY43 197.98,65.18 v1(197.99,65.16) ; v1(217.68,26.05) 217.53,26.05 217.22,25.74 217.22,24.05 CN11.225
  ART06 w0.087: v1(217.68,26.05) 217.36,25.73 217.13,25.73 216.99,25.87 216.99,27.6 216.82,27.77 216.69,27.77 216.42,27.5 216.3,27.5 216.18,27.62 216.18,27.75 216.45,28.02 216.45,28.14 216.33,28.26 216.2,28.26 215.97,28.03 215.89,28.03 215.76,28.15 215.76,28.31 215.96,28.51 215.96,28.63 215.77,28.82 215.77,31.02 219.14,34.39 219.14,48.31 217.23,50.22 217.23,51.44 216.97,51.7 216.97,58 216.47,58.49 210.85,58.49 209.61,59.74 201.08,59.74 198.17,62.64 198.17,64.98 v1(197.99,65.16)
M_A_DQ<43>: length 64.6
  TOP w0.109: U1.BB39 196.86,67.2 v1(197.04,67.1) ; CN11.212 213.97,30.78 v1(213.52,30.33)
  ART06 w0.087: v1(213.52,30.33) 213.84,30.33 214.01,30.51 214.01,31.66 217.44,35.09 217.44,47.56 214.68,50.33 214.68,55.74 214.48,55.94 211.38,55.94 211.29,56.03 211.29,56.2 211.38,56.29 214.28,56.29 214.36,56.37 214.36,56.55 214.28,56.63 210.12,56.63 208.77,57.98 206.4,57.98 206.03,58.35 204.6,58.35 204.06,57.81 199.55,57.81 196.71,60.65 196.71,63.46 196.49,63.68 196.49,65.42 196.65,65.58 196.65,66.86 196.89,67.1 v1(197.04,67.1)
M_A_DQ<44>: length 64.9
  TOP w0.109: v1(197.95,67.1) 197.76,67.21 U1.AY39 ; CN11.228 217.97,30.06 v1(217.55,29.64)
  ART06 w0.087: v1(217.55,29.64) 216.82,30.37 216.82,31.21 219.72,34.12 219.72,48.55 218.23,50.04 218.23,57.9 216.67,59.47 216.05,59.47 215.96,59.38 215.96,59.11 215.87,59.03 215.7,59.03 215.61,59.11 215.61,59.38 215.53,59.47 215.35,59.47 215.27,59.38 215.27,59.05 215.18,58.97 215.01,58.97 214.92,59.05 214.92,59.38 214.83,59.47 213.67,59.47 213.59,59.38 213.59,59.02 213.5,58.94 213.33,58.94 213.24,59.02 213.24,59.38 213.15,59.47 212.98,59.47 212.89,59.38 212.89,59.02 212.81,58.94 212.63,58.94 212.55,59.02 212.55,59.38 212.46,59.47 212.29,59.47 212.2,59.38 212.2,59.02 212.11,58.94 211.94,58.94 211.85,59.02 211.85,59.38 211.77,59.47 211.59,59.47 211.51,59.38 211.51,59.02 211.42,58.94 211.25,58.94 211.16,59.02 211.16,59.38 211.08,59.47 210.72,59.47 210.06,60.12 201.18,60.12 198.6,62.69 198.6,65.35 198.33,65.62 198.33,66.73 v1(197.95,67.1)
M_A_DQ<45>: length 64.9
  TOP w0.109: v1(197.04,67.73) 196.84,67.85 U1.BB38 ; v1(213.52,29.02) 214.97,30.47 CN11.216
  ART06 w0.087: v1(213.52,29.02) 213.31,29.02 213.14,29.19 213.14,31.22 217.12,35.19 217.12,47.47 213.82,50.76 213.82,53.09 212.09,54.83 209.97,54.83 209.89,54.91 209.89,55.09 209.97,55.17 211.72,55.17 211.8,55.26 211.8,55.43 211.72,55.52 209.71,55.52 209.28,55.95 209.28,57.12 208.61,57.79 206.1,57.79 205.79,58.1 204.71,58.1 204.2,57.6 199.53,57.6 196.53,60.59 196.53,63.35 196.33,63.55 196.33,65.5 196.48,65.65 196.48,67.36 196.86,67.73 v1(197.04,67.73)
M_A_DQ<46>: length 64.3
  TOP w0.109: CN11.215 214.72,24.05 214.72,25.26 v1(214.63,25.35) ; U1.BB42 v1(197.01,65.84)
  ART06 w0.087: v1(197.01,65.84) 197.02,65.83 197.02,65.71 196.66,65.35 196.66,63.89 196.89,63.66 196.89,60.71 198.97,58.63 200.71,58.63 201.33,58.01 203.87,58.01 204.44,58.58 206.12,58.58 206.49,58.21 209.63,58.21 210.94,56.89 214.45,56.89 215.02,56.32 215.02,50.39 217.73,47.68 217.73,34.97 214.32,31.55 214.32,28.87 213.56,28.12 213.56,27.79 213.48,27.7 213.06,27.7 212.97,27.62 212.97,27.44 213.06,27.36 213.48,27.36 213.56,27.27 213.56,27.1 213.48,27.01 213.06,27.01 212.97,26.92 212.97,26.75 213.06,26.66 213.48,26.66 213.56,26.58 213.56,25.64 213.85,25.35 v1(214.63,25.35)
M_A_DQ<47>: length 63.6
  TOP w0.109: v1(197.02,65.19) 197.01,65.2 U1.BB43 ; CN11.211 213.72,24.05 213.72,25.4 213.72,25.4 213.72,25.83 213.72,25.94 214.3,26.51 v1(214.56,26.51)
  ART06 w0.087: v1(197.02,65.19) 197.04,65.17 197.04,64.75 197.42,64.36 197.42,61.28 197.9,60.8 197.9,60.68 197.6,60.37 197.6,60.25 197.72,60.12 197.84,60.12 198.15,60.43 198.27,60.43 198.39,60.31 198.39,60.19 198.09,59.88 198.09,59.76 198.21,59.63 198.33,59.63 198.64,59.94 198.76,59.94 198.89,59.82 198.89,59.7 198.63,59.45 198.63,59.32 198.75,59.2 198.88,59.2 198.96,59.29 199.42,59.29 199.82,58.89 200.9,58.89 201.53,58.27 203.35,58.27 203.9,58.83 206.23,58.83 206.6,58.46 209.73,58.46 211.05,57.14 214.56,57.14 215.41,56.29 215.41,50.41 218.02,47.8 218.02,34.85 214.63,31.46 214.63,28.58 213.98,27.94 213.98,27.09 v1(214.56,26.51)
M_A_DQ<48>: length 55.3
  TOP w0.076: U1.AR48 199.89,62.45 199.89,61.31 200.41,60.79 200.41,57.85 201.01,57.25 201.01,55.42 201.09,55.34 201.54,55.34 201.62,55.27 201.62,54.6 201.53,54.51 201.38,54.51 201.31,54.58 201.31,54.96 201.24,55.04 201.09,55.04 201.01,54.96 201.01,53.76 201.13,53.63 201.23,53.63 v1(202.07,54.47)
  TOP w0.109: CN11.191 208.72,24.05 208.72,26.76 209.14,27.18 209.64,27.18 v1(209.72,27.09)
  ART06 w0.087: v1(202.07,54.47) 202.44,54.09 202.44,53.45 203.91,51.98 205.11,51.98 205.4,51.69 209.44,51.69 214.68,46.44 214.68,36.18 209.34,30.83 209.34,27.37 209.62,27.09 v1(209.72,27.09)
M_A_DQ<49>: length 55.7
  TOP w0.076: v1(202.05,53.25) 201.71,52.91 201.71,52.65 201.6,52.54 200.99,52.54 200.84,52.68 200.84,52.93 200.92,53 201.38,53 201.45,53.08 201.45,53.23 201.38,53.31 200.92,53.31 200.84,53.38 200.84,57.15 200.21,57.79 200.21,60.76 199.74,61.23 199.74,62.56 199.77,62.59 199.77,62.88 199.76,62.89 199.86,62.98 199.86,63.38 U1.AR47
  TOP w0.109: v1(209.72,25.34) 209.72,24.05 CN11.195
  ART06 w0.087: v1(202.05,53.25) 202.22,53.25 203.72,51.74 205,51.74 205.41,51.34 209.36,51.34 214.39,46.31 214.39,36.31 208.98,30.9 208.98,26.9 209.07,26.81 209.23,26.81 209.31,26.72 209.31,26.55 209.23,26.46 209.07,26.46 208.98,26.38 208.98,26.2 209.07,26.12 209.23,26.12 209.31,26.03 209.31,25.86 209.23,25.77 209.07,25.77 208.98,25.68 208.98,25.51 209.15,25.34 v1(209.72,25.34)
M_A_DQ<50>: length 54.5
  TOP w0.076: U1.AR49 200.06,62.28 200.06,61.38 200.57,60.86 200.57,57.92 201.17,57.32 201.17,55.98 v1(202.08,55.08)
  TOP w0.109: CN11.194 209.47,28.12 208.87,27.52 207.99,27.52 207.75,27.75 207.75,27.98 207.86,28.09 208.39,28.09 208.49,28.2 208.49,28.42 208.39,28.53 207.86,28.53 207.75,28.64 207.75,29.09 v1(208.49,29.82)
  ART06 w0.087: v1(208.49,29.82) 208.21,29.82 208.06,29.97 208.06,31.04 213.81,36.79 213.81,46.07 209.25,50.63 205.01,50.63 204.33,51.32 203.65,51.32 202.73,52.24 201.92,52.24 201.66,52.49 201.66,54.66 v1(202.08,55.08)
M_A_DQ<51>: length 54
  TOP w0.076: U1.AM45 201.42,64.12 201.72,63.82 201.72,62.91 201.77,62.67 201.8,62.61 201.83,62.58 201.83,58.66 203.45,57.04 203.45,55.4 203.58,55.27 203.58,54.72 v1(203.35,54.49)
  TOP w0.109: CN11.207 212.72,24.05 v1(212.72,25.34)
  ART06 w0.087: v1(203.35,54.49) 203.71,54.12 203.71,53.43 204.31,52.83 209.44,52.83 209.62,53.01 212.25,53.01 212.95,52.31 212.95,50.36 216.06,47.24 216.06,35.57 211.43,30.94 211.43,26.34 212.43,25.34 v1(212.72,25.34)
M_A_DQ<52>: length 56.9
  TOP w0.076: v1(202.06,52.64) 202.06,51.62 202.39,51.29 202.5,51.29 202.61,51.4 202.61,51.51 202.33,51.79 202.33,51.89 202.44,52 202.55,52 203.04,51.51 203.04,51.4 202.69,51.05 202.69,50.87 202.78,50.78 203.04,50.78 203.92,51.66 203.92,51.96 203.18,52.71 203.07,52.71 202.96,52.6 202.96,52.49 203.54,51.91 203.54,51.8 203.43,51.7 203.33,51.7 202.62,52.4 202.62,52.69 202.85,52.92 202.85,53.03 202.46,53.42 202.46,55.85 202.31,56 202.31,57.25 201.17,58.38 201.17,61.93 201.02,62.08 201.02,62.51 201.02,62.52 201.02,62.54 201.02,62.6 201.03,62.6 201.03,62.79 201.02,62.79 201.02,62.82 201.02,62.83 201.02,63.22 201.02,63.23 201.02,63.42 201.09,63.48 201.09,64.14 200.9,64.33 U1.AR45
  TOP w0.109: v1(208.49,30.94) 208.47,30.96 CN11.190
  ART06 w0.087: v1(202.06,52.64) 202.58,52.64 203.72,51.5 204.69,51.5 205.18,51.01 209.28,51.01 214.1,46.19 214.1,36.59 208.49,30.97 v1(208.49,30.94)
M_A_DQ<53>: length 53.6
  TOP w0.076: U1.AM47 201.44,63.64 201.19,63.13 201.19,62.9 201.22,62.78 201.22,62.61 201.19,62.47 201.19,62.23 201.34,62.08 201.34,58.45 202.48,57.32 202.48,57.19 202.49,57.18 202.49,56.21 202.64,56.06 202.64,53.84 202.85,53.63 203.08,53.63 203.3,53.85 v1(203.34,53.85)
  TOP w0.109: v1(210.7,26.67) 210.75,26.67 211.72,25.7 211.72,24.05 CN11.203
  ART06 w0.087: v1(210.7,26.67) 211.14,27.11 211.14,31.06 215.77,35.69 215.77,47.09 212.64,50.23 212.64,52.18 212.2,52.62 204.23,52.62 203.34,53.51 v1(203.34,53.85)
M_A_DQ<54>: length 53.1
  TOP w0.076: v1(203.03,55.78) 203.06,55.82 203.06,55.82 203.24,56 203.24,57.02 201.67,58.59 201.67,62.47 201.64,62.54 201.62,62.56 201.62,62.59 201.58,62.65 201.56,62.68 201.56,62.7 201.41,63.01 U1.AM48
  TOP w0.109: v1(212.47,29.24) 212.97,29.74 CN11.208
  ART06 w0.087: v1(203.03,55.78) 204.18,56.94 204.55,56.94 204.98,56.51 204.98,53.54 205.49,53.03 208.95,53.03 209.25,53.33 212.34,53.33 213.24,52.43 213.24,50.48 216.35,47.36 216.35,35.43 211.79,30.86 211.79,29.13 211.92,29 212.23,29 v1(212.47,29.24)
M_A_DQ<55>: length 52.4
  TOP w0.076: U1.AM49 201.5,62.3 201.5,58.52 202.64,57.38 202.64,57.26 202.76,57.14 202.76,56.55 v1(202.86,56.46)
  TOP w0.109: CN11.204 211.97,30.89 v1(212.47,30.39)
  ART06 w0.087: v1(202.86,56.46) 203.63,57.23 204.67,57.23 205.27,56.63 205.27,53.66 205.7,53.23 208.74,53.23 209.13,53.62 209.41,53.62 209.5,53.7 209.5,54.1 209.59,54.18 209.76,54.18 209.85,54.1 209.85,53.7 209.93,53.62 210.11,53.62 210.19,53.7 210.19,54.1 210.28,54.18 210.45,54.18 210.54,54.1 210.54,53.7 210.63,53.62 210.8,53.62 210.89,53.7 210.89,54.1 210.97,54.18 211.15,54.18 211.23,54.1 211.23,53.7 211.32,53.62 211.49,53.62 211.58,53.7 211.58,54.1 211.66,54.18 211.9,54.18 213.53,52.55 213.53,50.6 216.64,47.48 216.64,35.31 212.85,31.51 212.85,30.5 212.74,30.39 v1(212.47,30.39)
M_A_DQ<56>: length 66.4
  TOP w0.109: v1(199.75,65.82) 199.75,65.85 U1.AT42 ; CN11.236 219.97,29.59 v1(219.48,29.1)
  ART06 w0.087: v1(199.75,65.82) 199.75,65.71 199.4,65.35 199.4,64.88 199.87,64.41 199.87,63.78 199.78,63.69 199.45,63.69 199.36,63.6 199.36,63.43 199.45,63.35 199.78,63.35 199.87,63.26 199.87,63.04 200.02,62.88 200.02,62.76 199.87,62.61 199.87,62.49 200,62.36 200.12,62.36 200.27,62.51 200.39,62.51 200.65,62.25 203.5,62.25 204.06,61.7 205.18,61.7 205.62,62.13 206.01,62.13 206.65,61.49 207.64,61.49 208.2,62.05 211.15,62.05 211.54,61.65 212.83,61.65 213.53,60.96 217.22,60.96 220.03,58.15 220.03,54.53 219.67,54.18 219.67,50.46 221.14,48.99 221.14,33.76 218.76,31.37 218.76,28.29 218.95,28.1 219.19,28.1 219.27,28.19 219.27,28.47 219.36,28.56 219.53,28.56 219.62,28.47 219.62,28.19 219.71,28.1 219.87,28.1 220.03,28.26 220.03,28.91 219.85,29.1 v1(219.48,29.1)
M_A_DQ<57>: length 67
  TOP w0.109: v1(219.8,26.83) 219.22,26.26 219.22,24.05 CN11.233 ; U1.AT39 199.61,67.2 v1(199.78,67.1)
  ART06 w0.087: v1(199.78,67.1) 199.67,67.1 199.4,66.82 199.4,65.59 199.13,65.33 199.13,62.88 200.84,61.17 201.18,61.17 201.51,61.5 201.51,61.89 201.59,61.98 201.77,61.98 201.85,61.89 201.85,61.5 201.94,61.41 202.11,61.41 202.2,61.5 202.2,61.89 202.29,61.98 202.46,61.98 202.55,61.89 202.55,61.5 202.63,61.41 205,61.41 205.13,61.28 208.78,61.28 209.24,61.74 209.96,61.74 210.63,61.07 211.16,61.07 211.54,61.45 212.77,61.45 213.47,60.75 217.02,60.75 219.72,58.04 219.72,54.6 219.3,54.19 219.3,50.36 220.85,48.81 220.85,33.88 218.43,31.46 218.43,28.21 v1(219.8,26.83)
M_A_DQ<58>: length 64.8
  TOP w0.109: v1(200.75,65.16) 200.74,65.16 200.74,65.17 U1.AR43 ; CN11.245 v1(222.22,25.34)
  ART06 w0.081: v1(200.75,65.16) 200.75,65.14 201.2,64.69 201.2,63.8 201.85,63.14 216.64,63.14 220.94,58.84
  ART06 w0.087: 220.94,58.84 222.23,58.84 223.2,57.87 223.2,56.78 222.52,56.1 222.52,33.11 220.97,31.56 220.97,29.25 220.89,29.16 220.42,29.16 220.33,29.08 220.33,28.9 220.42,28.82 220.89,28.82 220.97,28.73 220.97,28.56 220.89,28.47 220.42,28.47 220.33,28.38 220.33,28.21 220.42,28.12 220.89,28.12 220.97,28.04 220.97,27.86 220.89,27.78 220.53,27.78 220.45,27.7 220.45,27.52 220.54,27.43 220.89,27.43 220.97,27.34 220.97,26.59 v1(222.22,25.34)
M_A_DQ<59>: length 65.9
  TOP w0.109: CN11.237 220.22,24.05 220.22,25.51 v1(219.72,26.01) ; v1(199.78,67.73) 199.61,67.84 U1.AT38
  ART06 w0.087: v1(199.78,67.73) 199.76,67.73 199.23,67.2 199.23,65.66 198.96,65.4 198.96,62.81 200.82,60.96 201.65,60.96 201.93,61.24 204.9,61.24 205.03,61.1 208.86,61.1 209.31,61.55 209.88,61.55 210.55,60.88 211.23,60.88 211.62,61.26 212.69,61.26 213.39,60.56 216.94,60.56 219.41,58.09 219.41,54.74 218.98,54.3 218.98,50.26 220.56,48.67 220.56,34 218.11,31.55 218.11,27.62 v1(219.72,26.01)
M_A_DQ<60>: length 65.7
  TOP w0.109: v1(200.7,67.73) 200.53,67.84 U1.AR38 ; v1(223.22,25.34) 223.22,24.05 CN11.249
  ART06 w0.087: v1(200.7,67.73) 201.25,67.18 201.25,65.69 203.27,63.67 218.32,63.67 221.89,60.11 223.19,60.11 224.68,58.62 224.68,56.93 223.45,55.7 223.45,32.6 222.51,31.66 222.51,28.88 222.79,28.6 222.79,28.39 222.65,28.25 222.42,28.25 222.33,28.16 222.33,27.99 222.42,27.9 222.7,27.9 222.79,27.81 222.79,25.55 223,25.34 v1(223.22,25.34)
M_A_DQ<61>: length 65.2
  TOP w0.109: CN11.246 222.47,30.84 v1(221.99,30.35) ; v1(200.7,67.1) 200.53,67.2 U1.AR39
  ART06 w0.087: v1(221.99,30.35) 221.61,30.73 221.61,31.25 223.1,32.74 223.1,55.76 224.39,57.05 224.39,58.49 223.2,59.67 221.91,59.67 219.55,62.03 219.41,62.03 219.3,61.92 219.3,61.79 220.5,60.59 220.5,60.46 220.37,60.34 220.26,60.34 218.86,61.75 218.86,62.83 218.19,63.5 202.11,63.5 201.59,64.01 201.59,65.11 201.08,65.62 201.08,66.71 v1(200.7,67.1)
M_A_DQ<62>: length 65
  TOP w0.109: CN11.250 223.47,30.36 222.13,29.02 221.99,29.02 v1(221.98,29.03) ; U1.AR42 v1(200.72,65.81)
  ART06 w0.087: v1(221.98,29.03) 221.98,27.46 221.79,27.27 221.52,27.27 221.32,27.47 221.32,31.42 222.81,32.91 222.81,55.94 223.51,56.64 223.51,58 222.22,59.29 220.75,59.29 216.73,63.32 202.01,63.32 201.42,63.91 201.42,65 200.72,65.7 200.72,65.81 v1(200.72,65.81)
M_A_DQ<63>: length 65.5
  TOP w0.109: v1(219.48,30.4) 219.38,30.3 219.11,30.3 218.97,30.44 CN11.232 ; v1(199.76,65.2) 199.76,65.21 U1.AT43
  ART06 w0.087: v1(219.48,30.4) 219.35,30.27 219.15,30.27 219.08,30.34 219.08,31.28 221.43,33.64 221.43,49.19 219.97,50.65 219.97,54.08 220.32,54.43 220.32,58.1 217.29,61.13 216.75,61.13 216.66,61.22 216.66,61.38 216.57,61.46 216.4,61.46 216.31,61.38 216.31,61.22 216.23,61.13 215.35,61.13 215.27,61.22 215.27,61.88 215.18,61.96 215.01,61.96 214.92,61.88 214.92,61.22 214.83,61.13 214.34,61.13 214.25,61.22 214.25,61.41 214.17,61.5 213.99,61.5 213.91,61.41 213.91,61.22 213.82,61.13 213.6,61.13 212.3,62.42 212.08,62.42 211.99,62.34 211.99,61.93 211.9,61.85 211.73,61.85 211.64,61.93 211.64,62.34 211.56,62.42 210.95,62.42 210.86,62.34 210.86,62.31 210.77,62.22 210.6,62.22 210.51,62.31 210.51,62.34 210.43,62.42 210.25,62.42 210.17,62.34 210.17,62.31 210.08,62.22 209.91,62.22 209.82,62.31 209.82,62.34 209.73,62.42 209.56,62.42 209.47,62.34 209.47,62.31 209.39,62.22 209.21,62.22 209.13,62.31 209.13,62.34 209.04,62.42 208.87,62.42 208.78,62.34 208.78,62.31 208.7,62.22 208.52,62.22 208.44,62.31 208.44,62.34 208.35,62.42 207.69,62.42 207.61,62.34 207.61,61.86 207.52,61.77 207.35,61.77 207.26,61.86 207.26,62.34 207.17,62.42 207,62.42 206.91,62.34 206.91,61.86 206.83,61.77 206.65,61.77 206.57,61.86 206.57,62.34 206.48,62.42 205.31,62.42 205.22,62.34 205.22,62.01 205.13,61.92 204.96,61.92 204.87,62.01 204.87,62.34 204.79,62.42 204.61,62.42 204.53,62.34 204.53,62.01 204.44,61.92 204.27,61.92 204.18,62.01 204.18,62.34 204.09,62.42 200.72,62.42 200.04,63.1 200.04,64.5 199.78,64.77 199.78,65.18 v1(199.76,65.2)
M_A_DQS_DN#<0>: length 49.1
  TOP w0.076: v1(186.12,56.81) 186.33,56.6 186.73,56.6 188.57,58.44 188.57,61.45 188.64,61.51 188.64,61.99 188.51,62.12 188.5,62.12 188.5,62.15 188.49,62.16 188.49,62.49 188.51,62.56 188.51,62.84 188.41,63.01 188.41,63.33 188.38,63.36 U1.BY47
  TOP w0.109: CN11.53 172.22,24.05 172.22,25 172.46,25.23 172.46,26.08 172.3,26.24 172.14,26.24 172.06,26.16 172.06,26.16 171.89,26 v1(171.89,25.97)
  ART06 w0.101: v1(171.89,25.97) 171.87,25.97 171.18,26.66 171.18,28.15 172.06,29.03 172.06,39.34 183.69,50.97 183.69,52.21 184.43,52.96 184.43,55.67 185.12,56.36 185.75,56.36 185.85,56.46 185.94,56.46 186.12,56.63 v1(186.12,56.81)
M_A_DQS_DN#<1>: length 55.5
  TOP w0.109: v1(161.23,25.96) 161.35,26.08 161.79,26.08 161.82,26.05 161.82,25.14 161.72,25.04 161.72,24.05 CN11.11 ; U1.CC41 v1(186.97,66.46)
  ART06 w0.101: v1(186.97,66.46) 186.86,66.46 186.63,66.23 186.63,64.63 184.54,62.54 183.52,62.54 175.66,54.68 175.66,52.88 173.28,50.49 173.28,50.33 162.08,39.13 162.08,28.11 162.25,27.95 162.25,26.66 162.25,26.34 162.12,26.22 161.8,26.22 161.72,26.14 161.41,26.14 161.24,25.96 v1(161.23,25.96)
M_A_DQS_DN#<2>: length 46.8
  TOP w0.076: v1(188.01,52.67) 188.46,53.11 188.46,53.12 188.57,53.12 188.91,53.46 188.91,56.54 189.23,56.85 189.85,56.85 190.93,57.93 190.93,59.37 190.81,59.48 190.81,59.92 190.81,60.81 190.81,61.23 190.81,61.23 190.81,61.24 190.42,61.63 190.42,61.99 190.56,62.14 190.57,62.14 190.57,62.49 190.53,62.64 190.54,62.81 190.6,62.9 190.63,63.12 190.56,63.23 190.56,63.43 190.61,63.57 190.67,63.62 190.77,63.62 190.86,63.54 190.86,63.43 U1.BR47
  TOP w0.109: CN11.74 177.47,31.31 177.55,31.24 177.55,30.35 177.4,30.2 177.17,30.2 v1(176.99,30.38)
  ART06 w0.101: v1(176.99,30.38) 176.99,30.33 176.87,30.21 176.82,30.21 176.67,30.36 176.67,31.49 176.77,31.59 177,31.59 177.1,31.69 177.1,31.89 177,32 176.77,32 176.67,32.1 176.67,32.3 176.77,32.4 177,32.4 177.1,32.5 177.1,32.71 177,32.81 176.77,32.81 176.67,32.91 176.67,33.29 177.81,34.43 177.81,37.7 178.1,37.99 178.1,38.55 177.9,38.75 177.9,38.89 178.05,39.04 178.19,39.04 178.47,38.75 178.86,38.75 179.18,39.07 179.18,39.46 178.89,39.74 178.89,39.88 179.04,40.03 179.18,40.03 179.37,39.84 179.95,39.84 180.24,40.14 180.24,42.74 187.05,49.54 187.05,51.24 187.77,51.96 187.77,52.43 v1(188.01,52.67)
M_A_DQS_DN#<3>: length 55.1
  TOP w0.109: U1.BV41 v1(189.72,66.46) ; CN11.32 166.97,31.16 167.08,31.06 167.08,30.08 166.97,29.96 166.72,29.96 166.47,30.2 v1(166.47,30.23)
  ART06 w0.101: v1(166.47,30.23) 166.34,30.23 166.15,30.42 166.15,31.28 166.25,31.38 166.4,31.38 166.5,31.48 166.5,31.68 166.4,31.79 166.25,31.79 166.15,31.89 166.15,32.09 166.25,32.19 166.4,32.19 166.5,32.29 166.5,32.49 166.4,32.6 166.25,32.6 166.15,32.7 166.15,34.49 166.25,34.59 166.82,34.59 167.09,34.86 167.09,35.31 166.82,35.58 166.25,35.58 166.15,35.68 166.15,35.89 166.25,35.99 166.82,35.99 167.09,36.26 167.09,36.71 166.82,36.98 166.25,36.98 166.15,37.08 166.15,37.93 179.61,51.39 179.61,53.33 179.8,53.53 179.8,55.8 182.2,58.19 184.59,58.19 186.54,60.14 186.54,60.9 189.03,63.4 189.03,64.49 189.32,64.78 189.32,66.36 189.43,66.46 v1(189.72,66.46)
M_A_DQS_DN#<4>: length 53.8
  TOP w0.076: U1.AV46 198.29,63.85 198.68,63.47 198.68,62.93 198.75,62.81 198.75,62.6 198.69,62.5 198.69,62.5 198.69,62.21 198.85,62.04 198.85,57.04 199.05,56.85 199.34,56.85 v1(199.5,57.01)
  TOP w0.109: v1(206.18,26.51) 206.18,26.45 206.06,26.33 205.74,26.33 205.67,26.33 205.28,25.93 205.28,25.25 205.28,25.24 205.22,25.18 205.22,24.05 CN11.177
  ART06 w0.101: v1(199.5,57.01) 199.5,56.9 199.61,56.78 199.8,56.78 199.84,56.74 199.86,56.74 200.07,56.53 200.07,53.93 200.6,53.41 200.6,52.14 201.79,50.95 202.17,50.95 204.06,49.06 208.29,49.06 212.11,45.24 212.11,38.2 209.05,35.13 209.05,34.43 207.03,32.42 206.33,32.42 205.07,31.16 205.07,28.42 205.45,28.04 205.45,26.71 205.74,26.42 206.09,26.42 v1(206.18,26.51)
M_A_DQS_DN#<5>: length 63.7
  TOP w0.109: v1(216.56,26.51) 216.46,26.4 215.98,26.4 215.74,26.16 215.74,26.03 215.74,26.03 215.74,25.12 215.72,25.11 215.72,24.05 CN11.219 ; U1.AY41 v1(197.95,66.46)
  ART06 w0.101: v1(197.95,66.46) 197.77,66.46 197.6,66.29 197.6,64.9 197.83,64.66 197.83,61.66 199.97,59.52 209.37,59.52 210.7,58.19 215.76,58.19 216.51,57.44 216.51,51.56 216.63,51.45 216.63,50.2 218.74,48.09 218.74,34.56 215.34,31.16 215.34,26.88 216.02,26.2 216.26,26.2 v1(216.56,26.51)
M_A_DQS_DN#<6>: length 54.1
  TOP w0.076: v1(201.9,56.3) 201.9,56.4 201.8,56.5 201.74,56.5 201.36,56.88 201.36,57.37 200.74,58 200.74,60.93 200.73,60.94 200.73,60.98 200.25,61.46 200.25,62.08 200.4,62.23 200.4,62.46 200.34,62.59 200.34,62.82 200.43,63 200.43,63.08 200.38,63.2 200.38,63.28 200.66,63.87 200.79,64 U1.AN46
  TOP w0.109: v1(209.99,30.38) 209.99,30.38 210.11,30.38 210.83,29.66 210.83,29.21 210.93,29.1 211.34,29.1 211.51,29.27 211.51,29.94 210.71,30.74 210.71,30.9 210.47,31.13 CN11.198
  ART06 w0.101: v1(201.9,56.3) 201.9,56.38 202.07,56.55 202.17,56.55 202.32,56.41 202.32,55.98 202.45,55.84 202.45,55.39 202.61,55.23 202.61,53.6 204.03,52.19 209.56,52.19 209.74,52.01 210.89,52.01 211.01,51.89 211.71,51.89 211.92,51.69 211.92,51.39 211.81,51.29 211.54,51.29 211.27,51.02 211.27,50.57 211.54,50.3 211.81,50.3 211.92,50.2 211.92,49.79 215.08,46.62 215.08,35.97 210.42,31.32 210.42,30.32 210.36,30.26 210.11,30.26 v1(209.99,30.38)
M_A_DQS_DN#<7>: length 65.4
  TOP w0.109: U1.AR41 v1(200.69,66.46) ; CN11.240 220.97,31.32 221.21,31.08 221.21,30.9 221.13,30.82 221.03,30.82 220.92,30.72 220.92,30.5 221.03,30.39 221.1,30.39 221.21,30.28 221.21,30.13 221.07,29.99 220.78,29.99 v1(220.48,30.29)
  ART06 w0.101: v1(200.69,66.46) 200.53,66.46 200.33,66.27 200.33,64.88 200.55,64.67 200.55,64.47 200.65,64.37 200.83,64.37 200.93,64.27 200.93,64.07 200.83,63.97 200.65,63.97 200.55,63.87 200.55,63.2 200.86,62.88 213.29,62.88 213.5,62.68 213.5,62.55 213.6,62.45 213.8,62.45 213.9,62.55 213.9,62.68 214.11,62.88 214.46,62.88 214.66,62.68 214.66,62.55 214.76,62.45 214.97,62.45 215.07,62.55 215.07,62.68 215.27,62.88 215.78,62.88 217.04,61.62 217.46,61.62 221.63,57.45 221.63,54.03 222.07,53.59 222.07,53 221.66,52.59 220.83,52.59 220.73,52.49 220.73,51.05 220.83,50.95 221.03,50.95 221.13,51.05 221.13,51.91 221.4,52.19 221.85,52.19 222.13,51.91 222.13,33.33 220.18,31.38 220.18,30.46 220.34,30.29 v1(220.48,30.29)
M_A_DQS_DP<0>: length 49.1
  TOP w0.076: U1.BY46 188.28,63.76 188.6,63.44 188.6,63.06 188.7,62.89 188.7,62.54 188.68,62.47 188.68,62.24 188.69,62.23 188.69,62.2 188.82,62.07 188.82,61.44 188.75,61.36 188.75,58.4 186.79,56.45 186.46,56.45 v1(186.2,56.18)
  TOP w0.109: CN11.55 172.72,24.05 172.72,26.19 172.34,26.57 v1(171.89,26.57)
  ART06 w0.101: v1(186.2,56.18) 186.16,56.18 185.19,56.18 184.61,55.59 184.61,52.88 183.86,52.14 183.86,52 183.98,51.88 183.98,50.84 172.35,39.21 172.35,28.91 171.47,28.03 171.47,26.78 171.68,26.57 v1(171.89,26.57)
M_A_DQS_DP<1>: length 55.5
  TOP w0.109: v1(161.23,26.57) 161.45,26.35 161.9,26.35 162.09,26.16 162.09,25.16 162.22,25.02 162.22,24.05 CN11.13 ; U1.CE41 v1(186.06,66.46)
  ART06 w0.101: v1(161.23,26.57) 161.23,26.55 161.35,26.43 161.6,26.43 161.95,26.79 161.95,27.82 161.79,27.99 161.79,39.25 175.49,52.95 175.49,54.75 183.45,62.71 184.46,62.71 186.45,64.7 186.45,66.37 186.36,66.46 v1(186.06,66.46)
M_A_DQS_DP<2>: length 46.9
  TOP w0.076: v1(188.01,53.29) 188.03,53.27 188.5,53.27 188.76,53.52 188.76,56.66 188.79,56.69 189.14,57.04 189.78,57.04 190.74,58.01 190.74,59.29 190.62,59.41 190.62,59.43 190.62,60.74 190.62,60.74 190.62,61.15 190.62,61.16 190.62,61.16 190.23,61.55 190.23,62.07 190.38,62.22 190.38,62.47 190.34,62.63 190.34,62.84 190.42,62.97 190.43,63.08 190.37,63.17 190.37,63.47 190.45,63.67 190.53,63.76 U1.BR46
  TOP w0.109: v1(176.99,29.78) 177.14,29.93 177.51,29.93 177.82,30.24 177.82,31.13 177.97,31.29 CN11.76
  ART06 w0.101: v1(188.01,53.29) 187.52,52.79 187.52,52.13 186.75,51.36 186.75,49.66 179.95,42.86 179.95,40.26 179.82,40.13 179.49,40.13 179.3,40.32 178.92,40.32 178.6,40 178.6,39.62 178.88,39.33 178.88,39.19 178.74,39.05 178.6,39.05 178.31,39.33 177.92,39.33 177.61,39.01 177.61,38.63 177.8,38.43 177.8,38.11 177.51,37.82 177.51,34.56 176.37,33.41 176.37,30.24 176.84,29.78 v1(176.99,29.78)
M_A_DQS_DP<3>: length 55.1
  TOP w0.109: v1(166.47,29.63) 166.56,29.63 166.62,29.69 167.08,29.69 167.35,29.96 167.35,30.84 167.47,30.97 CN11.34 ; U1.BW41 v1(188.8,66.46)
  ART06 w0.101: v1(166.47,29.63) 166.47,29.68 165.86,30.3 165.86,34.61 166.13,34.88 166.7,34.88 166.8,34.98 166.8,35.19 166.7,35.29 166.13,35.29 165.86,35.56 165.86,36.01 166.13,36.28 166.7,36.28 166.8,36.38 166.8,36.59 166.7,36.69 166.13,36.69 165.86,36.96 165.86,38.06 178.56,50.75 178.72,50.75 179.43,51.46 179.43,53.4 179.63,53.6 179.63,55.87 182.13,58.37 184.51,58.37 186.36,60.21 186.36,60.98 188.85,63.47 188.85,64.56 189.15,64.86 189.15,66.12 v1(188.8,66.46)
M_A_DQS_DP<4>: length 53.8
  TOP w0.076: v1(199.48,56.34) 199.48,56.57 199.39,56.66 198.97,56.66 198.66,56.96 198.66,61.96 198.5,62.13 198.5,62.55 198.56,62.65 198.56,62.75 198.49,62.86 198.49,63.27 198.41,63.36 U1.AV47
  TOP w0.109: v1(206.18,25.93) 206.05,26.06 205.79,26.06 205.54,25.82 205.54,25.36 205.55,25.35 205.72,25.18 205.72,24.05 CN11.179
  ART06 w0.101: v1(199.48,56.34) 199.48,56.4 199.64,56.56 199.79,56.56 199.9,56.46 199.9,53.86 200.42,53.33 200.42,52.06 201.71,50.77 202.07,50.77 202.34,50.42 202.5,50.21 203.94,48.77 208.17,48.77 211.81,45.12 211.81,38.32 208.75,35.25 208.75,34.55 206.91,32.71 206.21,32.71 204.78,31.28 204.78,28.3 205.15,27.92 205.15,27.64 205.05,27.54 204.92,27.54 204.81,27.44 204.81,27.23 204.92,27.13 205.05,27.13 205.15,27.03 205.15,26.59 205.62,26.13 205.98,26.13 v1(206.18,25.93)
M_A_DQS_DP<5>: length 63.7
  TOP w0.109: CN11.221 216.22,24.05 216.22,25.03 216.1,25.15 216.1,25.24 216.06,25.29 216,25.35 216,26.05 216.09,26.14 216.38,26.14 216.56,25.95 v1(216.56,25.91) ; U1.BB41 v1(197.04,66.46)
  ART06 w0.101: v1(216.56,25.91) 215.9,25.91 215.05,26.76 215.05,31.29 218.45,34.69 218.45,47.96 216.33,50.08 216.33,57.36 215.68,58.01 210.63,58.01 209.3,59.34 199.89,59.34 197.65,61.58 197.65,64.59 197.42,64.82 197.42,66.23 197.18,66.46 v1(197.04,66.46)
M_A_DQS_DP<6>: length 54.1
  TOP w0.076: v1(201.93,56.96) 201.91,56.94 201.62,56.94 201.54,57.02 201.54,57.46 200.92,58.08 200.92,61.01 200.92,61.01 200.92,61.05 200.88,61.09 200.88,61.1 200.44,61.54 200.44,62 200.59,62.15 200.59,62.51 200.53,62.64 200.53,62.77 200.62,62.95 200.62,63.12 200.6,63.18 200.6,63.28 200.67,63.36 U1.AN47
  TOP w0.109: CN11.200 210.97,30.85 211.78,30.05 211.78,29.16 211.45,28.83 210.82,28.83 210.56,29.1 210.56,29.55 210.23,29.88 210.09,29.88 210.02,29.81 210.02,29.8 209.99,29.78 v1(209.99,29.78)
  ART06 w0.101: v1(201.93,56.96) 202.12,56.77 202.26,56.77 202.49,56.54 202.49,56.48 202.49,56.48 202.49,56.05 202.63,55.92 202.63,55.47 202.79,55.3 202.79,53.68 204.1,52.37 209.63,52.37 209.81,52.19 211.83,52.19 212.21,51.81 212.21,51.27 211.94,51 211.67,51 211.56,50.89 211.56,50.69 211.67,50.59 211.94,50.59 212.21,50.32 212.21,49.91 215.38,46.74 215.38,35.85 210.72,31.19 210.72,30.2 210.48,29.97 210.18,29.97 v1(209.99,29.78)
M_A_DQS_DP<7>: length 65.5
  TOP w0.109: v1(220.48,29.69) 220.52,29.73 221.18,29.73 221.47,30.02 CN11.242 ; U1.AT41 v1(199.78,66.46)
  ART06 w0.101: v1(199.78,66.46) 199.93,66.46 200.16,66.24 200.16,64.81 200.37,64.59 200.37,63.13 200.79,62.71 213.22,62.71 213.32,62.6 213.32,62.47 213.52,62.27 213.87,62.27 214.08,62.47 214.08,62.6 214.18,62.71 214.38,62.71 214.48,62.6 214.48,62.47 214.69,62.27 215.04,62.27 215.24,62.47 215.24,62.6 215.35,62.71 215.71,62.71 216.97,61.45 217.38,61.45 221.22,57.61 221.22,57.45 221.33,57.33 221.33,53.91 221.78,53.47 221.78,53.13 221.54,52.89 220.71,52.89 220.43,52.61 220.43,50.92 220.71,50.65 221.15,50.65 221.43,50.92 221.43,51.79 221.53,51.89 221.73,51.89 221.83,51.79 221.83,33.45 219.88,31.5 219.88,30.23 219.87,30.22 220.2,29.89 220.28,29.89 v1(220.48,29.69)
M_A_DRAMRST: length 4.8
  TOP w0.127: CN11.108 185.97,32.25 185.97,33.71 v1(185.46,34.22)
  BOTTOM w0.305: R747.1 183.76,33.49 R749.2 183.77,34.32 C887.2 185.36,34.32 v1(185.46,34.22)
M_A_ODT<0>: length 81.8
  TOP w0.135: CN11.155 199.72,22.24 199.54,22.05 v1(199.1,22.05) ; U1.BJ39 193.11,67.36 v1(193.37,67.1)
  ART06 w0.108: v1(193.37,67.1) 193.18,67.1 193,66.92 193,64.92 192.67,64.59 192.67,63.13 191.81,62.28 191.81,61.68 191.29,61.15 191.29,50.87 191.11,50.68 191.11,44.62 190.82,44.34 190.67,44.34 190.21,44.79 190.06,44.79 185.9,40.64 185.9,40.48 186.05,40.33 186.2,40.33 190.06,44.18 190.21,44.18 190.36,44.03 190.36,43.88 186.1,39.62 186.1,38.4 184.24,36.54 184.24,32.5 184.96,31.78 184.96,27.33 184.85,27.22 184.67,27.22 184.56,27.11 184.56,26.89 184.67,26.79 184.85,26.79 184.96,26.68 184.96,26.46 184.85,26.35 184.67,26.35 184.56,26.25 184.56,26.03 184.84,25.75 184.84,25.1 184.53,24.79 184.53,22.21 186.06,20.68 198,20.68 199.1,21.78 v1(199.1,22.05)
M_A_ODT<1>: length 74.1
  TOP w0.076: U1.BB45 196.42,64.19 196.74,63.86 196.74,62.67 196.83,62.58 196.83,61.39 196.83,61.39 196.83,61.33 196.83,61.32 196.83,58.72 v1(197.44,58.12)
  TOP w0.135: v1(199.15,30.12) 199.17,30.1 199.17,28.25 200.29,27.13 200.59,27.13 200.87,27.41 200.87,28.08 201.57,28.78 205.95,28.78 206.06,28.67 206.06,28.35 205.94,28.24 203.12,28.24 202.98,28.1 202.98,27.83 203.12,27.7 205.62,27.7 205.78,27.53 205.78,27.26 205.68,27.16 202.71,27.16 202.44,27.43 202.44,28.1 202.31,28.24 201.82,28.24 201.44,27.85 201.44,26.85 201.22,26.64 201.22,24.05 CN11.161
  ART06 w0.108: v1(197.44,58.12) 197.98,58.12 198.58,57.52 198.58,51.93 198.58,51.77 199.9,50.45 199.9,49.99 203.34,46.55 207.19,46.55 209.69,44.06 209.69,39.26 202.04,31.62 201.78,31.62 201.19,31.02 200.04,31.02 v1(199.15,30.12)
M_A_RAS_N: length 81.6
  TOP w0.135: v1(192.45,66.46) 192.21,66.71 U1.BM41 ; CN11.152 198.97,30.92 199.93,29.96 199.93,28.13 v1(200.44,27.62)
  ART06 w0.108: v1(192.45,66.46) 192.24,66.46 192.04,66.26 192.04,65.8 192.04,65.76 191.22,64.94 191.22,63.26 190.13,62.17 190.13,61.4 190.29,61.24 190.29,51.18 189.77,50.65 189.77,47.96 183.87,42.06 183.87,38.63 182.81,37.57 182.81,31.85 182.22,31.27 182.22,22.87 185.56,19.54 198.51,19.54 201.13,22.15 201.13,27.71 201.03,27.8 200.63,27.8 v1(200.44,27.62)
M_A_WE_N: length 76.8
  TOP w0.135: CN11.151 198.72,22.79 198.54,22.61 v1(198.37,22.61) ; U1.BG43 193.62,65.41 v1(193.39,65.17)
  ART06 w0.108: v1(198.37,22.61) 198.58,22.4 198.58,21.72 197.83,20.97 186.2,20.97 184.83,22.33 184.83,24.73 185.25,25.14 185.25,32.22 184.57,32.9 184.57,36.38 191.11,42.91 191.11,43.06 190.95,43.22 190.8,43.22 186.78,39.2 186.64,39.2 186.48,39.35 186.48,39.51 191.42,44.45 191.42,50.55 191.48,50.61 191.48,61.05 192.04,61.61 192.04,62.13 193.08,63.17 193.08,64.53 193.39,64.84 v1(193.39,65.17)
M_B_A0: length 91.5
  TOP w0.135: CN19.144 194.97,17.02 194.77,16.81 193.91,16.81 193.78,16.94 193.37,16.94 v1(193.27,17.04) ; U1.P42 v1(210.76,65.83)
  ART03 w0.108: v1(210.76,65.83) 210.76,63.19 211.58,62.38 211.58,56.35 212.38,55.54 212.38,52.3 211.93,51.85 211.93,46.65 204.93,39.65 199.17,39.65 195.32,35.8 195.32,30.65 193.72,29.05 193.72,26.47 193.07,25.82 192.22,25.82 191.83,25.44 191.83,23.88 191.94,23.77 192.16,23.77 192.27,23.88 192.27,25.08 192.37,25.19 192.59,25.19 192.7,25.08 192.7,21.91 192.47,21.69 187.72,21.69 187.41,21.37 187.41,21.18 187.56,21.04 187.7,21.04 187.91,21.24 190.2,21.24 190.31,21.14 190.31,20.92 190.2,20.81 188.03,20.81 187.92,20.7 187.92,20.49 188.03,20.38 190.2,20.38 190.31,20.27 190.31,20.06 190.2,19.95 188.03,19.95 187.92,19.84 187.92,19.62 188.05,19.5 193.22,19.5 193.38,19.33 193.38,17.16 v1(193.27,17.04)
M_B_A1: length 97.9
  TOP w0.076: U1.Y49 207.62,62.34 207.62,62.06 207.62,62.06 207.62,62.02 207.62,61.22 207.62,61.22 207.96,60.88 207.96,60.38 208.1,60.24 208.1,60.22 209.02,59.31 209.02,58.79 209.83,57.98 209.83,53.88
  TOP w0.135: 209.83,53.88 209.83,53.51 209.3,52.98 209.3,51.49 209.43,51.36 211.32,51.36 211.45,51.22 211.45,47.85 211.32,47.72 211.05,47.72 210.92,47.85 210.92,50.68 210.78,50.82 210.51,50.82 210.38,50.68 210.38,47.85 210.24,47.72 209.97,47.72 209.84,47.85 209.84,50.68 209.7,50.82 209.43,50.82 209.3,50.68 209.3,47.52 209.67,47.15 211.9,47.15 212.5,47.75 212.5,51.61 213.4,52.51 213.4,52.81 v1(214.23,53.64) ; CN19.133 192.22,13.95 v1(192.17,14.01)
  ART03 w0.108: v1(214.23,53.64) 214.63,53.23 214.63,50.77 214.16,50.3 214.16,45.72 205.83,37.39 203.15,37.39 200.36,34.6 200.36,33.81 200.75,33.41 200.75,32.79 198.11,30.14 198.11,28.24 197.75,27.89 197.75,27.12 198.14,26.73 198.14,25.17 197.52,24.55 196.8,24.55 195.99,23.73 195.99,21.83 196.49,21.33 196.49,15.31 194.82,13.64 192.54,13.64 v1(192.17,14.01)
M_B_A2: length 91.7
  TOP w0.076: v1(215.84,54) 215.1,54 214.99,54.12 214.99,56.25 214.64,56.6 212.38,56.6 209.84,59.14 209.84,59.65 208.93,60.56 208.93,61.11 208.98,61.16 208.98,61.2 209.21,61.43 209.21,62.38 209.17,62.42 209.17,62.51 209.16,62.52 209.16,62.53 209.05,62.63 209.05,62.77 U1.U48
  TOP w0.135: CN19.132 191.97,18.37 v1(191.39,17.79)
  ART03 w0.108: v1(191.39,17.79) 190.92,17.32 190.92,16.7 190.18,15.96 189.6,15.96 189.49,15.85 189.49,15.63 189.6,15.53 190.18,15.53 190.28,15.42 190.28,15.16 190.51,14.93 190.51,13.91 191.82,12.6 196.27,12.6 196.38,12.71 196.38,13.27 196.48,13.37 196.7,13.37 196.81,13.27 196.81,12.86 196.95,12.71 197.18,12.71 197.18,12.71 197.24,12.71 198.13,13.6 198.13,16.4 198.58,16.86 198.58,22.11 200.71,24.24 200.71,24.33 200.61,24.43 200.61,24.59 200.76,24.74 200.91,24.74 201.02,24.63 201.17,24.63 201.32,24.78 201.32,25.61 201.21,25.72 200.78,25.72 200.67,25.83 200.67,26.04 200.78,26.15 201.21,26.15 201.32,26.26 201.32,26.47 201.21,26.58 200.78,26.58 200.67,26.69 200.67,26.9 200.78,27.01 201.21,27.01 201.32,27.12 201.32,27.78 201.43,27.89 201.93,27.89 202.04,28 202.04,28.21 201.93,28.32 201.43,28.32 201.32,28.43 201.32,28.85 201.63,29.16 201.78,29.16 202.31,28.64 202.46,28.64 202.61,28.79 202.61,28.94 202.09,29.47 202.09,29.62 202.55,30.08 202.55,31.71 212.8,41.96 212.95,41.96 213.21,41.71 213.36,41.71 213.52,41.86 213.52,42.01 213.26,42.27 213.26,42.42 213.41,42.58 213.56,42.58 213.82,42.32 213.97,42.32 214.13,42.47 214.13,42.62 213.87,42.88 213.87,43.03 214.02,43.19 214.17,43.19 214.43,42.93 214.59,42.93 214.74,43.08 214.74,43.23 214.48,43.49 214.48,43.65 214.63,43.8 214.79,43.8 215.04,43.54 215.2,43.54 215.35,43.69 215.35,43.84 215.09,44.1 215.09,44.26 215.24,44.41 215.4,44.41 215.66,44.15 215.81,44.15 215.96,44.3 215.96,44.46 215.7,44.71 215.7,44.87 215.85,45.02 216.01,45.02 216.27,44.76 216.42,44.76 216.57,44.91 216.57,45.07 216.41,45.23 216.41,45.58 216.55,45.72 216.55,46.45 216.55,46.45 216.55,52.51 216.26,52.81 216.26,53.84 216.09,54 v1(215.84,54)
M_B_A3: length 100.7
  TOP w0.076: U1.Y45 207.99,64 207.99,63.31 207.9,63.21 207.9,62.87 207.89,62.87 207.89,62.75 207.89,62.71 207.89,62.57 207.89,62.47 207.9,62.46 207.9,62.11 207.79,62 207.79,61.95 207.79,61.95 207.79,61.29 208.13,60.95 208.13,60.44 208.27,60.31 208.27,60.29 209.18,59.38 209.18,58.86 210.25,57.79 210.25,57.56
  TOP w0.135: 210.25,57.56 211.33,56.48 211.33,55.92 211.46,55.79 212,55.79 212.16,55.63 212.16,55.36 212.05,55.25 211.46,55.25 211.33,55.11 211.33,54.84 211.46,54.71 211.73,54.71 211.87,54.57 211.87,54.31 211.73,54.17 211.46,54.17 211.33,54.04 211.33,53.59 211.19,53.45 210.92,53.45 210.79,53.59 210.79,56.24 210.67,56.36 210.4,56.36 210.25,56.21 210.25,53.45 209.62,52.82 209.62,51.9 209.8,51.72 210.04,51.72 210.18,51.85 210.18,52.66 210.31,52.79 211.17,52.79 211.31,52.66 211.31,52.39 211.17,52.26 210.85,52.26 210.72,52.12 210.72,51.85 210.85,51.72 211.68,51.72 213.14,53.18 213.14,53.37 212.95,53.56 212.76,53.56 211.98,52.78 211.79,52.78 211.59,52.97 211.59,53.16 212.65,54.21 213.06,54.21 213.52,53.75 213.71,53.75 v1(214.24,54.27) ; v1(191.7,14.4) 191.69,14.4 191.69,14.4 191.69,13.79 191.72,13.75 CN19.131
  ART03 w0.108: v1(191.7,14.4) 191.69,14.4 191.68,14.39 191.68,13.91 192.21,13.38 195.08,13.38 196.8,15.1 196.8,21.58 196.36,22.02 196.36,22.96 198.46,25.05 198.46,26.5 198.66,26.7 198.66,27.69 198.46,27.89 198.46,30 201.48,33.02 201.48,34.09 201.37,34.2 200.8,34.2 200.69,34.31 200.69,34.52 200.8,34.63 201.37,34.63 201.48,34.74 201.48,35.15 203.3,36.96 203.47,36.96 203.63,36.81 203.63,36.68 201.99,35.05 201.99,34.89 202.14,34.74 202.3,34.74 204.61,37.05 205.99,37.05 214.48,45.55 214.48,50.17 214.94,50.64 214.94,54.28 214.75,54.48 214.44,54.48 v1(214.24,54.27)
M_B_A4: length 99
  TOP w0.076: 214.67,53.13 214.62,53.18 214.62,53.77 214.62,56.05 214.4,56.27 212.24,56.27 209.51,59 209.51,59.51 208.6,60.43 208.6,61.24 208.6,61.25 208.6,61.32 208.87,61.59 208.87,62.05 208.68,62.24 208.68,62.45 208.73,62.59 208.73,62.73 208.69,62.93 208.69,63.14 U1.U47
  TOP w0.135: 214.67,53.13 214.67,50.88 213.69,49.9 213.69,46.76 213.89,46.55 214.4,46.55 214.57,46.73 214.57,47.15 214.71,47.28 216.65,47.28 216.79,47.15 216.79,46.88 216.65,46.74 215.25,46.74 215.11,46.61 215.11,46.34 215.25,46.2 217.14,46.2 217.5,46.56 217.5,51.13 v1(215.84,52.79) ; CN19.128 190.97,19.72 190.82,19.57 190.82,17.28 191.05,17.05 v1(191.32,17.05)
  ART03 w0.108: v1(191.32,17.05) 191.32,16.63 190.69,16 190.69,15.18 190.89,14.97 190.89,13.89 191.92,12.86 195.49,12.86 197.73,15.11 197.73,16.45 198.29,17.01 198.29,21.87 197.96,22.2 197.96,22.81 198.3,23.15 199.11,23.15 200.31,24.35 200.31,26.92 200.9,27.51 200.9,28.97 201.54,29.62 201.54,31.15 216.24,45.85 216.24,52.38 v1(215.84,52.79)
M_B_A5: length 94.9
  TOP w0.076: U1.R49 210.15,62.35 210.15,61.41 210.35,61.2 210.35,61.19 210.72,60.82 210.72,60.68 210.72,60.62 210.72,60.36 212.25,58.83 212.25,58.83 213.68,57.4 213.92,57.4 213.95,57.43 216.04,57.43 216.3,57.18 216.3,55.13
  TOP w0.135: v1(190.26,17.42) 190.47,17.64 CN19.126 ; 216.3,55.13 216.3,52.85 217.91,51.24 217.91,50.88 218.19,50.6 218.96,50.6 219.31,50.95 219.31,52.87 218.22,53.95 v1(217.81,53.95)
  ART03 w0.108: v1(217.81,53.95) 218.24,53.53 218.24,44.24 206.2,32.2 205.52,32.2 204.76,31.44 204.76,28.01 204.03,27.28 204.03,23.3 200.54,19.81 200.54,18.47 200.96,18.05 200.96,11.72 200.53,11.29 189.74,11.29 188.85,12.18 188.85,17.4 189.12,17.67 190.01,17.67 v1(190.26,17.42)
M_B_A6: length 97.2
  TOP w0.076: U1.U49 209.04,62.27 209.04,61.52 208.77,61.25 208.77,61.18 208.76,61.18 208.76,60.49 209.68,59.58 209.68,59.07 212.31,56.43 214.47,56.43 214.79,56.12 214.79,53.86 214.96,53.69
  TOP w0.135: CN19.127 190.72,14.98 191.02,15.27 v1(191.14,15.27) ; v1(215.86,52.17) 216.01,52.17 217.15,51.02 217.15,50.63 217.01,50.49 216.26,50.49 216.12,50.63 216.12,51.24 215.98,51.39 215.71,51.39 215.58,51.26 215.58,50.63 214.99,50.04 214.99,48.34 215.13,48.2 215.4,48.2 215.53,48.34 215.53,49.82 215.67,49.95 215.94,49.95 216.07,49.82 216.07,48.34 216.21,48.2 216.48,48.2 216.61,48.34 216.61,49.82 216.75,49.95 217.01,49.95 217.15,49.82 217.15,47.92 216.81,47.58 214.12,47.58 214.01,47.69 214.01,49.79 214.96,50.75 214.96,52.43 215.1,52.57 215.22,52.57 215.36,52.7 215.36,52.97 215.22,53.1 215.1,53.1 214.96,53.24 214.96,53.69
  ART03 w0.108: v1(191.14,15.27) 191.24,15.17 191.24,13.91 192.03,13.12 195.31,13.12 197.38,15.19 197.38,16.6 198.02,17.24 198.02,21.65 197.66,22.01 197.66,22.55 197.46,22.75 197.46,23.12 197.85,23.51 198.77,23.51 199.88,24.62 199.88,30.34 200.46,30.92 200.86,30.92 215.86,45.92 215.86,52.16 v1(215.86,52.17)
M_B_A7: length 93
  TOP w0.076: v1(218.97,56.19) 218.4,56.77 218.4,57.98 217.84,58.53 213.95,58.53 213.25,59.24 213.25,59.24 211.79,60.69 211.79,62.16 211.74,62.47 211.68,62.64 211.68,62.78 211.74,62.91 211.74,63.16 211.71,63.21 211.68,63.27 211.48,63.48 U1.M47
  TOP w0.135: v1(188.46,17.67) 189.14,17.67 189.47,18 CN19.122
  ART03 w0.108: v1(218.97,56.19) 218.99,56.19 219.8,55.38 219.8,43.56 208.03,31.79 208.03,25.08 202.95,19.99 202.95,11.46 201.47,9.98 188.52,9.98 187.13,11.38 187.13,16.83 187.96,17.67 v1(188.46,17.67)
M_B_A8: length 94
  TOP w0.076: v1(218.99,56.8) 218.93,56.74 218.66,56.74 218.56,56.84 218.56,58.11 217.97,58.7 214.03,58.7 211.96,60.77 211.96,62.32 211.92,62.49 211.87,62.64 211.87,62.78 211.92,62.89 211.92,63.17 211.88,63.25 211.83,63.38 211.83,63.72 211.75,63.8 211.7,63.92 211.48,64.14 U1.M45
  TOP w0.135: CN19.125 190.22,15.41 190.05,15.58 188.35,15.58 v1(188.21,15.44)
  ART03 w0.108: v1(188.21,15.44) 187.95,15.44 187.65,15.13 187.65,11.78 188.93,10.51 201.21,10.51 202.31,11.6 202.31,11.77 202.21,11.87 201.86,11.87 201.75,11.99 201.75,12.21 201.84,12.31 202.3,12.31 202.41,12.41 202.41,12.63 202.3,12.74 201.99,12.74 201.88,12.84 201.88,13.06 201.99,13.17 202.3,13.17 202.41,13.28 202.41,20.35 206.59,24.53 206.59,25.02 206.7,25.13 206.85,25.13 206.96,25.24 206.96,25.46 206.85,25.56 206.7,25.56 206.59,25.67 206.59,25.89 206.7,26 206.85,26 206.96,26.1 206.96,26.32 206.85,26.43 206.7,26.43 206.59,26.54 206.59,26.75 206.7,26.86 206.85,26.86 206.96,26.97 206.96,27.18 206.85,27.29 206.7,27.29 206.59,27.4 206.59,27.8 206.72,27.93 207.13,27.93 207.42,28.23 207.42,32.02 219.18,43.79 219.18,53.68 218.6,54.27 218.6,56.41 v1(218.99,56.8)
M_B_A9: length 94.8
  TOP w0.076: v1(215.82,55.84) 215.38,56.28 215.38,56.41 214.72,57.07 214.06,57.07 214.06,57.07 213.52,57.07 212.95,57.64 212.95,57.66 211.92,58.69 211.92,58.69 210.38,60.23 210.38,60.66 210.02,61.03 210.02,61.07 209.81,61.28 209.81,61.28 209.78,61.31 209.78,62.15 209.76,62.17 209.76,62.57 209.78,62.59 209.78,62.61 209.81,62.65 209.81,62.85 209.88,62.92 209.88,63.39 U1.R47
  TOP w0.135: v1(189.8,13.88) 189.8,13.88 189.75,13.88 189.75,13.88 189.4,13.88 189.22,13.7 CN19.121
  ART03 w0.108: v1(189.8,13.88) 189.81,13.88 191.6,12.08 197.67,12.08 198.77,13.18 198.77,14.46 199.12,14.81 199.12,14.93 199.01,15.04 198.87,15.04 198.76,15.14 198.76,15.36 198.87,15.47 199.01,15.47 199.12,15.58 199.12,15.79 199.01,15.9 198.87,15.9 198.76,16.01 198.76,16.22 198.87,16.33 199.01,16.33 199.12,16.44 199.12,17.31 199.21,17.4 199.5,17.4 199.65,17.26 199.65,13.13 199.79,12.99 200.04,12.99 200.16,13.11 200.16,17.59 199.91,17.83 199.26,17.83 199.12,17.98 199.12,18.9 199.23,19.01 199.6,19.01 199.7,19.12 199.7,19.34 199.6,19.45 199.23,19.45 199.12,19.55 199.12,19.77 199.23,19.88 199.6,19.88 199.7,19.99 199.7,20.2 199.6,20.31 199.23,20.31 199.12,20.42 199.12,20.99 200.22,22.09 200.22,22.72 200.79,23.29 200.94,23.29 201.15,23.08 201.31,23.08 201.46,23.23 201.46,23.38 201.25,23.59 201.25,23.75 201.4,23.9 201.55,23.9 201.77,23.69 201.92,23.69 202.07,23.84 202.07,23.99 201.86,24.21 201.86,24.36 202.01,24.51 202.16,24.51 202.38,24.3 202.53,24.3 202.76,24.53 202.76,24.9 202.87,25 203.02,25 203.13,25.11 203.13,25.33 203.02,25.44 202.87,25.44 202.76,25.54 202.76,27.8 203.81,28.85 203.81,31.8 205.2,33.2 205.76,33.2 217.22,44.66 217.22,52.67 217.03,52.86 217.03,54.78 216.92,54.89 216.39,54.89 216.28,54.99 216.28,55.21 216.39,55.32 216.92,55.32 217.03,55.42 217.03,55.64 216.92,55.75 216.81,55.75 216.71,55.86 216.71,56.07 216.81,56.18 216.92,56.18 217.03,56.29 217.03,57.01 216.85,57.19 216.51,57.19 216.26,56.94 216.26,56.29 v1(215.82,55.84)

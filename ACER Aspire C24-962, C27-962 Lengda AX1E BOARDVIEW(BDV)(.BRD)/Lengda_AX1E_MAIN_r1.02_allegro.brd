# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DISP_UTILS: length 5.8
  TOP w0.075: 219.37,87.58 219.29,87.5 218.88,87.5 217.75,86.37 216.9,86.37 216.33,85.8 215.66,85.8 215.33,85.47 U1.D2
  TOP w0.102: R1398.1 219.37,87.58
DMIC_CLK0: length 5.2
  BOTTOM w0.109: R368.1 134.64,62.19 R319.1 134.11,60.86 134.11,58.13 133.97,57.99 CN2.7
DMIC_CLK0_PCH: length 45.7
  TOP w0.075: R347.2 163.24,66.84 v1(163.35,66.94)
  TOP w0.076: v1(174.29,68.4) 174.32,68.4 174.3,68.64 U1.DG36
  ART03 w0.087: v1(137.96,65.19) 137.99,65.16 154.32,65.16 155.75,66.59 158.09,66.59 158.55,67.05 163.12,67.05 163.22,66.94 v1(163.35,66.94) 163.39,66.9 163.7,67.22 172.87,67.22 172.96,67.13 173.64,67.13 173.87,67.36 173.87,67.68 174.29,68.1 v1(174.29,68.4)
  BOTTOM w0.109: v1(137.96,65.19) 136.86,65.19 136.52,64.85 136.36,64.85 136.22,64.98 136.06,64.98 135.91,64.83 135.91,64.67 136.05,64.53 136.05,64.38 135.3,63.63 135.3,61.68 R319.2
DMIC_CLK1: length 1.5
  BOTTOM w0.109: CN2.4 134.71,56.49 R334.1
DMIC_CLK1_PCH: length 50.8
  TOP w0.075: v1(166.8,66.28) 166.49,65.97 R312.2
  TOP w0.076: U1.DF38 174.82,67.54 v1(174.82,67.52)
  ART03 w0.087: v1(174.82,67.52) 174.82,67.16 174.61,66.95 174.6,66.95 174.52,66.87 172.49,66.87 172.36,67 172.06,67 171.99,66.93 167.39,66.93 166.8,66.34 v1(166.8,66.28)
  ART03 w0.102: v1(138.66,64.65) 138.68,64.68 155.84,64.68 157.26,66.1 158.4,66.1 158.92,66.62 162.72,66.62 163.04,66.3 166.77,66.3 v1(166.8,66.28)
  BOTTOM w0.109: v1(138.66,64.65) 138.62,64.65 137.88,63.91 137.29,63.91 136.96,63.58 136.96,63.46 136.85,63.35 136.75,63.35 136.64,63.24 136.64,63.02 136.75,62.91 136.85,62.91 136.96,62.8 136.96,60.94 136.46,60.43 136.46,59.7 135.56,58.8 135.26,58.8 135.11,58.66 135.11,58.49 135.24,58.36 135.56,58.36 135.67,58.25 R334.2
DMIC_CLK_CODEC: length 127.9
  TOP w0.109: v1(37.54,77.65) 37.46,77.65 C486.1 37.03,78.08 35.93,78.08 R407.2
  ART03 w0.087: v1(37.54,77.65) 38.09,77.1 46.98,77.1 48.65,75.42 50.64,75.42 50.9,75.16 55.42,75.16 56.62,76.36 57.92,76.36 58.27,76.71 61.99,76.71 v1(62.36,77.09)
  ART06 w0.087: v1(133.13,65.54) 131.45,67.21 131.45,70.57 130.95,71.07 130.95,76.74 123.09,84.6 122.5,84.6 121.89,83.99 120.79,83.99 120.1,84.69 111.82,84.69 110.3,86.21 92.31,86.21 86.86,80.76 86.86,76.13 84.9,74.17 82.44,74.17 80.73,72.46 66.99,72.46 v1(62.36,77.09)
  BOTTOM w0.109: R409.2 v1(37.54,77.65) ; v1(133.13,65.54) 133.68,65.54 134.61,64.6 R368.2
DMIC_DATA0: length 5.1
  BOTTOM w0.109: CN2.6 134.09,57.49 134.3,57.29 134.77,57.29 134.94,57.46 134.94,57.9 134.64,58.21 134.64,59.87 R394.1 R320.1
DMIC_DATA0_PCH: length 45.9
  TOP w0.075: v1(162.78,68.11) 162.76,68.1 R346.2
  TOP w0.076: U1.DG34 v1(174.17,69.39)
  ART03 w0.087: v1(174.17,69.39) 174.17,69.05 173.85,68.73 173.85,68.16 173.62,67.93 172.59,67.93 172.27,67.61 163.94,67.61 163.44,68.11 v1(162.78,68.11) 162.14,67.47 158.33,67.47 157.95,67.09 155.67,67.09 154.26,65.67 v1(139.1,65.67)
  BOTTOM w0.109: v1(139.1,65.67) 139.04,65.67 137.79,64.42 136.97,64.42 135.77,63.22 135.77,62.04 136.13,61.68 136.13,61.15 R320.2
DMIC_DATA1: length 2.4
  BOTTOM w0.109: CN2.3 134.44,55.99 R344.1 R432.1
DMIC_DATA1_PCH: length 50.9
  TOP w0.075: R311.2 166.7,65.19 v1(167.14,65.62)
  TOP w0.076: U1.DD39 175.9,67.05 175.15,67.05 174.74,66.64 v1(174.74,66.59)
  ART03 w0.087: v1(174.74,66.59) 174.26,66.1 170.12,66.1 170.06,66.17 167.68,66.17 v1(167.14,65.62)
  ART03 w0.102: v1(167.14,65.62) 166.27,65.62 165.99,65.9 162.92,65.9 162.63,66.2 159.18,66.2 158.66,65.67 157.46,65.67 155.97,64.18 v1(139.21,64.18)
  BOTTOM w0.109: R344.2 135.87,55.72 136.21,56.06 136.21,58.81 136.87,59.47 136.87,60.26 137.45,60.84 137.45,63 137.79,63.33 138.35,63.33 v1(139.21,64.18)
DMIC_DATA34_CODEC: length 149.5
  TOP w0.109: v1(35.47,72.29) 34.8,71.62 R399.2 34.35,71.92 34.35,74.53 33.93,74.95 R397.1
  ART03 w0.087: v1(63.28,77.63) 63.13,77.78 61.61,77.78 61.28,77.46 57.95,77.46 57.58,77.09 56.08,77.09 54.89,75.9 51.33,75.9 51.09,76.14 48.82,76.14 47.02,77.93 39.11,77.93 38.66,78.39 36.57,78.39 36.09,77.91 36.09,75.28 35.47,74.66 v1(35.47,72.29)
  ART06 w0.087: v1(138.24,62.08) 137.38,62.08 134.17,65.29 134.17,65.42 132.49,67.09 132.49,71.29 132.01,71.77 132.01,76.77 123.35,85.43 112.77,85.43 111.19,87 92.1,87 86.26,81.16 86.26,76.71 84.36,74.81 82.19,74.81 80.66,73.29 78.91,73.29 78.05,74.14 68.82,74.14 68.45,74.51 66.86,74.51 63.74,77.63 v1(63.28,77.63)
  BOTTOM w0.109: R432.2 135.97,54.93 136.48,55.44 136.48,58.48 137.23,59.23 137.23,60.05 137.87,60.69 137.87,61.71 v1(138.24,62.08)
DMIC_DATA_CODEC: length 132.5
  TOP w0.109: v1(36.46,77.63) 36.15,77.31 R406.1
  ART03 w0.087: v1(63.69,77.12) 62.97,77.12 62.61,77.48 61.83,77.48 61.46,77.12 58.12,77.12 57.75,76.75 56.37,76.75 55.17,75.56 51.1,75.56 50.85,75.81 48.82,75.81 47.05,77.58 38.52,77.58 38.04,78.07 36.9,78.07 v1(36.46,77.63)
  ART06 w0.087: v1(136.26,62.61) 133.72,65.16 133.72,65.52 131.92,67.32 131.92,70.95 131.44,71.43 131.44,76.82 123.17,85.09 112.27,85.09 110.75,86.61 92.16,86.61 86.47,80.93 86.47,76.4 84.63,74.56 82.28,74.56 80.64,72.93 67.23,72.93 63.69,76.47 v1(63.69,77.12)
  BOTTOM w0.109: R394.2 135.86,59.87 136.04,60.05 136.04,60.6 136.51,61.07 136.51,61.89 136.26,62.14 v1(136.26,62.61) ; R410.2 v1(36.46,77.63)
DP_RCOMP: length 2.6
  TOP w0.076: v1(209.92,86.67) 209.99,86.67 210.16,86.5 210.16,85.75 U1.R2
  BOTTOM w0.102: R23.2 209.99,86.67 v1(209.92,86.67)
DSW_PWROK: length 140.6
  TOP w0.075: v1(166.2,62.57) 165.8,62.97 R857.1 165.61,62.96 R93.2
  TOP w0.076: U1.DR48 170.2,63.03 169.88,62.72 169.88,62.19 169.72,62.03 169.17,62.03 168.56,61.42 168.19,61.42 167.42,62.19 167.1,62.19 166.72,62.57 v1(166.2,62.57)
  ART03 w0.102: v1(166.2,62.57) 164.24,60.61 156,60.61 152.93,63.69 135.76,63.69 135.16,63.08 130.35,63.08 127.92,60.65 124.62,60.65 124.4,60.43 122.54,60.43 120.29,58.18 115.15,58.18 114.73,57.76 112.94,57.76 112.52,57.34 108.09,57.34 107.59,57.84 105.99,57.84 105.18,58.65 101.65,58.65 101.46,58.45 99.29,58.45 99.18,58.56 81.89,58.56 79.55,60.9 78.35,60.9 77.79,60.33 74.84,60.33 73.66,61.51 56.27,61.51 55.41,62.37 50.23,62.37 v1(49.06,63.54)
  BOTTOM w0.102: U9.120 52.84,66.85 49.53,63.54 v1(49.06,63.54)
EC_MUTE#: length 10.1
  TOP w0.102: v1(43.21,63.3) 42.48,64.03 37.34,64.03 R380.2 36.73,64.64 U23.1
  BOTTOM w0.102: U9.30 42.56,62.91 42.95,63.3 v1(43.21,63.3)
EC_SLP_S0IX_N: length 133.4
  TOP w0.075: U1.DT12 169.81,80.04 168.62,80.04 168.44,80.22 166.57,80.22 166.56,80.23 164.63,80.23 163.85,81.02 163.85,81.34 163.82,81.38 163.22,81.38 163,81.6 161.97,81.6
  TOP w0.102: 161.97,81.6 159.58,81.6 159.06,81.07 157.82,81.07 R874.2 R873.1 156.67,81.01 156.14,81.01 155.57,81.58 v1(155.57,81.67) ; R157.1 58.04,76.02 58.04,74.47 57.2,73.63 57.2,69.9 v1(57.37,69.73)
  ART03 w0.102: v1(155.57,81.67) 155.47,81.67 152.79,84.36 149.75,84.36 149.17,84.94 145.34,84.94 145.03,84.63 135.31,84.63 127.07,76.39 127.07,76.22 119.03,68.17 113.79,68.17 112.44,66.82 100.93,66.82 99.72,65.61 96.75,65.61 95.95,64.81 83.26,64.81 82.62,65.45 81.24,65.45 78.86,67.83 64.1,67.83 63.01,68.92 61.88,68.92 61.49,69.3 59.16,69.3 58.41,70.05 57.69,70.05 v1(57.37,69.73)
EC_SMI_LP_N: length 143.5
  TOP w0.075: 167.49,81.66 167.53,81.66 167.82,81.37 168.61,81.37 168.64,81.35 168.8,81.28 170.06,81.28 U1.DT11
  TOP w0.102: 167.49,81.66 167.35,81.66 166.4,82.61 164.97,82.61 R156.2 164.64,82.29 163.92,83.02 v1(163.88,83.02)
  ART03 w0.075: v1(163.88,83.02) 163.66,83.23 163.02,83.23 161.97,82.19
  ART03 w0.102: v1(52.45,68.26) 52.46,68.27 55.03,68.27 55.54,68.77 60.67,68.77 61.61,67.83 63.38,67.83 63.89,67.32 70.41,67.32 70.99,66.74 73.7,66.74 74.11,67.15 77.12,67.15 79.17,65.1 82.46,65.1 83.09,64.47 96.19,64.47 96.85,65.13 99.93,65.13 101.39,66.58 107.75,66.58 108.81,65.52 113.15,65.52 114.96,67.33 121.07,67.33 123.46,69.72 124.72,69.72 126.91,71.91 126.94,71.91 126.95,71.92 133.82,71.92 135.75,73.86 135.75,78.59 136.24,79.08 144.04,79.08 144.47,79.5 148.22,79.5 149.27,78.45 153.79,78.45 155.96,80.63 156.88,80.63 157.85,81.6 157.85,82.66 158.13,82.95 158.37,82.95 159.52,81.81 161.59,81.81 161.97,82.19
  BOTTOM w0.102: U9.15 48.56,64.44 49.99,65.87 49.99,66.61 51.18,67.79 51.99,67.79 v1(52.45,68.26)
EC_VCC: length 6
  BOTTOM w0.305: R834.2 50.69,57.68 R833.2 50.67,59.43 50.16,59.94 U9.11
EDID_SCL: length 12
  BOTTOM w0.102: R596.1 45.45,14.53 44.94,14.53
  BOTTOM w0.114: R596.1 45.58,14.66 46.6,15.67 46.6,17.07 46.68,17.15 46.68,19.03 47.67,20.02 47.67,20.5 48.53,21.36 48.53,22.62 48.69,22.78 U42.29 ; U43.6 43.31,14.53 44.94,14.53
EDID_SDA: length 12
  BOTTOM w0.114: U42.30 48.53,23.18 48.31,22.97 48.31,21.51 48.02,21.23 47.86,21.23 47.56,21.52 47.37,21.52 47.21,21.36 47.21,21.23 47.53,20.9 47.53,20.74 47.39,20.59 47.39,20.1 46.19,18.9 46.19,17.68 44.94,16.43 R600.1 44.93,15.8 U43.5
EDP_AUX_DN: length 245.5
  TOP w0.076: v1(208.03,88.61) 208.15,88.74 208.39,88.74 208.45,88.67 208.45,87.95 207.92,87.42 207.92,85.92 207.67,85.67 207.67,84.95 207.96,84.66 U1.W4
  ART03 w0.075: 197.07,97.44 197.09,97.43 197.11,97.43 198.22,96.32 198.22,93.31 201.34,90.2 201.34,88.19 202.91,86.62 204.3,86.62 205.13,85.79 207.16,85.79 207.57,86.19 207.57,88.73 207.68,88.84 207.8,88.84 v1(208.03,88.61)
  ART03 w0.087: v1(80.74,79.7) 80.92,79.88 85.83,79.88 88.46,82.5 88.46,95.79 97.21,104.54 111.82,104.54 113.8,106.52 122.93,106.52 123.65,107.23 130.31,107.23 133.27,104.26 137.59,104.26 138.62,105.28 139.15,105.28 141.32,107.45 157.84,107.45 158.11,107.18 164.27,107.18 164.92,107.82 167.42,107.82 168.05,107.2 174.45,107.2 175.79,105.86 186.93,105.86 190.37,102.41 190.37,100.48 192.83,98.02 196.5,98.02 197.07,97.44
  BOTTOM w0.109: C187.2 62.64,30.6 63.09,30.6 63.58,31.08 63.58,34.5 63.47,34.61 62.09,34.61 61.86,34.85 61.86,35.25 62.09,35.49 63.47,35.49 63.58,35.6 63.58,35.81 63.47,35.92 62.09,35.92 61.86,36.16 61.86,36.56 62.09,36.8 63.47,36.8 63.58,36.91 63.58,37.65 62.79,38.43 62.79,52.24 65.85,55.3 73.51,55.3 74.54,56.32 78.14,56.32 84.15,62.33 84.15,74.26 82.45,75.96 82.45,79.64 82.01,80.09 81.12,80.09 v1(80.74,79.7)
EDP_AUX_DP: length 245.6
  TOP w0.076: v1(208.03,89.21) 208.35,88.89 208.45,88.89 208.6,88.74 208.6,87.89 208.07,87.36 208.07,85.82 207.85,85.6 207.85,85.25 U1.W3
  ART03 w0.075: v1(208.03,89.21) 207.8,88.99 207.62,88.99 207.42,88.79 207.42,86.26 207.1,85.94 205.19,85.94 204.36,86.77 202.97,86.77 201.49,88.25 201.49,90.26 198.37,93.38 198.37,96.38 197.22,97.54 197.22,97.56 197.2,97.57
  ART03 w0.087: 197.2,97.57 196.57,98.2 192.91,98.2 190.55,100.55 190.55,102.49 187,106.04 175.86,106.04 174.52,107.38 168.13,107.38 167.5,108.01 164.84,108.01 164.2,107.36 158.18,107.36 157.92,107.63 141.25,107.63 139.08,105.47 138.54,105.47 137.52,104.44 133.35,104.44 130.38,107.41 123.57,107.41 122.86,106.7 113.72,106.7 111.75,104.72 97.13,104.72 88.27,95.86 88.27,82.58 85.76,80.06 80.98,80.06 v1(80.74,80.31)
  BOTTOM w0.109: v1(80.74,80.31) 82.1,80.31 82.67,79.73 82.67,76.05 84.37,74.35 84.37,62.23 78.23,56.1 74.63,56.1 73.6,55.08 65.94,55.08 63.01,52.15 63.01,38.53 63.8,37.74 63.8,36.82 63.56,36.58 62.19,36.58 62.08,36.47 62.08,36.25 62.19,36.14 63.56,36.14 63.8,35.91 63.8,35.5 63.56,35.27 62.19,35.27 62.08,35.16 62.08,34.94 62.19,34.83 63.56,34.83 63.8,34.59 63.8,30.99 63.18,30.38 62.29,30.38 C196.2
EDP_DISP_UTIL: length 28.2
  ART03 w0.102: v1(28.46,41.17) 28.5,41.2 37.07,41.2 42.38,35.89 42.38,32.03 43.75,30.66 v1(48.74,30.66)
  BOTTOM w0.102: v1(28.46,41.17) 28.62,41 R522.1 ; R587.1 v1(48.74,30.66)
EDP_HPD: length 152.4
  TOP w0.076: U1.DW11 167.55,80.95 167.37,81.14 165.1,81.14 164.99,81.25 164.99,81.54
  TOP w0.102: 163.01,82.15 163.37,81.79 164.74,81.79 164.99,81.54
  TOP w0.109: 163.01,82.15 159.22,82.15 158.86,81.79 157.23,81.79 v1(157.16,81.87)
  ART03 w0.087: 152.64,85.22 156.44,81.41 156.7,81.41 v1(157.16,81.87)
  ART03 w0.102: 152.64,85.22 149.79,85.22 149.65,85.36 145.27,85.36 144.86,84.94 135.12,84.94 126.56,76.39 126.56,76.34 119.23,69 114.09,69 112.16,67.07 100.49,67.07 99.44,66.02 96.53,66.02 95.67,65.16 88.67,65.16 v1(88.52,65.31)
  BOTTOM w0.109: R591.1 65.68,21.68 Q42.2 66.19,21.68 67.2,22.69 R592.1 R828.2 67.76,23.52 67.99,23.76 67.99,25.93 67.12,26.8 67.12,45.91 66.45,46.57 66.45,51.66 67.3,52.51 74.26,52.51 75.49,53.73 79.26,53.73 87.68,62.15 87.68,64.47 v1(88.52,65.31)
EDP_HPD_8625: length 7.7
  BOTTOM w0.114: R593.1 61.62,21.85 60.36,21.85 60.17,21.66 58.09,21.66 57.25,22.49 57.25,23.27 56.54,23.98 U42.11
EDP_HPD_CONN: length 2.1
  BOTTOM w0.102: R591.2 64.51,22.63 Q42.3 63.51,22.05 R593.2
EDP_TX_DN<0>: length 249.1
  TOP w0.076: U1.Y5 207.13,84.52 207.08,85.04 207.01,85.19 206.94,85.36 206.94,85.59 207,85.7 207,85.81 206.96,85.97 206.96,86.5 207.1,86.64 207.1,88.27 207.01,88.36 206.87,88.36 v1(206.61,88.1)
  ART03 w0.075: v1(206.61,88.1) 206.74,88.23 206.99,88.23 207.07,88.15 207.07,86.57 206.83,86.34 205.26,86.34 204.5,87.09 203.2,87.09 201.86,88.43 201.86,90.45 198.76,93.55 198.76,97.02 198.25,97.54 198.25,97.56 198.23,97.57
  ART03 w0.087: 198.23,97.57 196.66,99.15 193.71,99.15 191.36,101.5 191.36,102.71 187.36,106.7 176.13,106.7 174.8,108.03 168.4,108.03 167.77,108.66 164.57,108.66 163.93,108.02 158.47,108.02 158.19,108.29 140.89,108.29 139.08,106.49 138.64,106.49 137.31,105.16 133.6,105.16 130.67,108.09 123.33,108.09 122.61,107.37 113.37,107.37 111.46,105.46 96.86,105.46 86.53,95.13 86.53,82.76 85.75,81.98 v1(80.89,81.98)
  BOTTOM w0.109: v1(80.89,81.98) 82.66,81.98 83.52,81.12 83.52,76.25 85.81,73.96 85.81,62.65 78.54,55.37 74.91,55.37 73.84,54.3 66.55,54.3 64.62,52.37 64.62,49.14 63.87,48.4 63.87,48.18 63.98,48.07 64.38,48.07 64.62,47.84 64.62,47.43 64.38,47.2 63.98,47.2 63.87,47.09 63.87,46.87 63.98,46.76 64.38,46.76 64.62,46.52 64.62,46.12 64.38,45.88 63.98,45.88 63.87,45.77 63.87,45.56 63.98,45.45 64.38,45.45 64.62,45.21 64.62,44.81 64.38,44.57 63.98,44.57 63.87,44.46 63.87,44.24 63.98,44.13 64.38,44.13 64.62,43.9 64.62,43.5 64.38,43.26 64,43.26 63.87,43.13 63.87,42.52 64.62,41.78 64.62,41.18 64.07,40.64 64.07,39.83 64.62,39.28 64.62,30.27 62.88,28.54 59.46,28.54 C152.2
EDP_TX_DN<1>: length 250.3
  TOP w0.076: U1.Y1 207.5,86.22 207.5,90.71 207.69,90.89 207.83,90.89 v1(208.08,91.15)
  ART03 w0.075: v1(208.08,91.15) 208.02,91.09 207.02,91.09 205.73,89.8 205.73,87.3 205.6,87.17 204.98,87.17 204.62,87.52 203.28,87.52 202.2,88.6 202.2,94.51 199.75,96.96 199.75,97.54 199.76,97.55 199.76,97.57
  ART03 w0.087: v1(81.06,83.53) 81.3,83.29 84.72,83.29 85.35,83.92 85.35,94.9 96.58,106.14 111.1,106.14 112.99,108.03 122.33,108.03 123.05,108.75 130.98,108.75 133.9,105.83 137.05,105.83 138.37,107.16 138.73,107.16 140.53,108.95 158.54,108.95 158.8,108.69 163.65,108.69 164.27,109.31 168.04,109.31 168.67,108.68 175.09,108.68 176.4,107.36 187.72,107.36 189.8,105.29 191.93,105.29 196.84,100.38 197.4,100.38 199.76,98.01 199.76,97.57
  BOTTOM w0.109: C154.2 59.34,24.9 62.3,24.9 63.02,25.62 63.02,27.66 65.46,30.1 65.46,51.92 67.08,53.54 74.14,53.54 75.19,54.59 78.87,54.59 86.61,62.33 86.61,74.59 84.36,76.84 84.36,82.04 82.92,83.48 81.11,83.48 v1(81.06,83.53)
EDP_TX_DN<2>: length 3.9
  TOP w0.075: C6059.2 209.05,88.66 209.08,88.64
  TOP w0.076: 209.08,88.64 209.08,88.01 208.26,87.19 208.26,86.67 208.26,85.73 U1.V2
EDP_TX_DN<3>: length 7.1
  TOP w0.075: C6061.2 211.3,89.34 210.9,89.34 210.59,89.03 210.59,88.79 210.59,88.78 ; 210.59,88.72 210.59,88.72 210.59,88.59 210.59,88.59
  TOP w0.076: U1.V3 208.51,84.8 208.51,84.58 208.61,84.47 208.9,84.47 209.01,84.58 209.01,84.74 208.8,84.95 208.8,85.07 208.96,85.3 208.96,85.59 208.92,85.72 208.92,85.85 208.98,86.02 208.98,87.12 209.73,87.87 210.01,87.87 210.59,88.45 210.59,88.59 ; 210.59,88.72 210.59,88.78
EDP_TX_DP<0>: length 249
  TOP w0.076: U1.Y3 207.43,84.81 207.51,84.89 207.51,85.04 207.43,85.11 207.3,85.11 207.19,85.22 207.17,85.26 207.12,85.4 207.12,85.55 207.17,85.66 207.18,85.83 207.13,86 207.13,86.42 207.25,86.54 207.25,88.34 207.07,88.51 206.8,88.51 v1(206.61,88.7)
  ART03 w0.075: 198.11,97.44 198.12,97.43 198.14,97.43 198.61,96.96 198.61,93.49 201.71,90.38 201.71,88.37 203.13,86.94 204.44,86.94 205.19,86.19 206.89,86.19 207.22,86.51 207.22,88.22 207.05,88.38 206.92,88.38 v1(206.61,88.7)
  ART03 w0.087: 198.11,97.44 196.58,98.96 193.64,98.96 191.17,101.43 191.17,102.63 187.28,106.52 176.05,106.52 174.73,107.85 168.32,107.85 167.69,108.48 164.65,108.48 164,107.83 158.39,107.83 158.11,108.11 140.97,108.11 139.16,106.3 138.71,106.3 137.39,104.98 133.53,104.98 130.59,107.91 123.4,107.91 122.69,107.19 113.44,107.19 111.53,105.28 96.93,105.28 86.71,95.06 86.71,82.68 85.83,81.8 81.31,81.8 v1(80.89,81.38)
  BOTTOM w0.109: C153.2 59.46,28.76 62.79,28.76 64.4,30.36 64.4,39.19 63.85,39.74 63.85,40.73 64.4,41.28 64.4,41.69 63.66,42.43 63.66,43.22 63.91,43.48 64.29,43.48 64.4,43.59 64.4,43.8 64.29,43.91 63.89,43.91 63.66,44.15 63.66,44.55 63.89,44.79 64.29,44.79 64.4,44.9 64.4,45.12 64.29,45.23 63.89,45.23 63.66,45.46 63.66,45.87 63.89,46.1 64.29,46.1 64.4,46.21 64.4,46.43 64.29,46.54 63.89,46.54 63.66,46.78 63.66,47.18 63.89,47.42 64.29,47.42 64.4,47.53 64.4,47.74 64.29,47.85 63.89,47.85 63.66,48.09 63.66,48.49 64.4,49.24 64.4,52.46 66.46,54.52 73.75,54.52 74.82,55.59 78.45,55.59 85.6,62.74 85.6,73.87 83.3,76.16 83.3,81.03 82.57,81.76 81.27,81.76 v1(80.89,81.38)
EDP_TX_DP<1>: length 250.3
  TOP w0.076: v1(208.08,90.54) 207.88,90.74 207.75,90.74 207.65,90.64 207.65,85.96 207.4,85.7 U1.Y2
  ART03 w0.075: v1(208.08,90.54) 207.69,90.94 207.08,90.94 205.88,89.73 205.88,87.24 205.66,87.02 204.91,87.02 204.56,87.37 203.22,87.37 202.05,88.54 202.05,94.44 199.6,96.89 199.6,97.54 199.58,97.55 199.58,97.57
  ART03 w0.087: 199.58,97.57 199.58,97.94 197.32,100.2 196.77,100.2 191.85,105.11 189.72,105.11 187.65,107.18 176.33,107.18 175.01,108.5 168.59,108.5 167.96,109.13 164.35,109.13 163.72,108.5 158.73,108.5 158.46,108.77 140.6,108.77 138.81,106.97 138.45,106.97 137.12,105.65 133.83,105.65 130.9,108.57 123.13,108.57 122.41,107.85 113.07,107.85 111.17,105.95 96.66,105.95 85.53,94.83 85.53,83.84 84.79,83.11 81.23,83.11 v1(81.06,82.93)
  BOTTOM w0.109: C155.2 59.59,25.11 62.21,25.11 62.8,25.71 62.8,27.75 65.24,30.19 65.24,52.01 66.99,53.76 74.05,53.76 75.1,54.81 78.78,54.81 86.39,62.42 86.39,74.5 84.14,76.75 84.14,81.95 82.83,83.27 81.39,83.27 v1(81.06,82.93)
EDP_TX_DP<2>: length 3.8
  TOP w0.076: C6060.2 209.83,88.57 209.77,88.5 209.36,88.5 209.23,88.37 209.23,87.95 208.43,87.15 208.43,86.96 208.51,86.88 208.52,86.88 208.6,86.8 208.6,86.65 208.52,86.57 208.51,86.57 208.44,86.5 208.44,86.46 208.44,86.2 U1.V1
EDP_TX_DP<3>: length 7.1
  TOP w0.075: 210.44,88.63 210.44,88.65 ; 210.44,88.66 210.44,89.09 210.79,89.45 210.79,89.85 C6062.2
  TOP w0.076: U1.V5 208.21,84.66 208.24,84.97 208.39,85.1 208.69,85.21 208.78,85.35 208.78,85.57 208.75,85.69 208.75,85.88 208.8,86.05 208.8,86.49 208.8,86.5 208.8,86.52 208.83,86.54 208.83,87.18 209.66,88.02 209.95,88.02 210.44,88.51 210.44,88.63 ; 210.44,88.65 210.44,88.66
EDRAM_OPIO_RCOMP: length 2.3
  TOP w0.075: 218.97,80.06 R841.1
  TOP w0.305: 218.97,80.06 218.26,80.06 217.74,79.54 217.4,79.54 U1.A14
EMMC_RCOMP: length 3.9
  TOP w0.201: R163.2 166.53,71.94 167.76,71.94 168.58,72.75 169.4,72.75 U1.DU28
ENA: length 2.4
  BOTTOM w0.305: R553.2 31.94,50.54 31.15,49.75 U37.9
ENPVCC/I2C_ADDR: length 28.1
  ART06 w0.102: v1(46.39,23.81) 46.4,23.8 46.4,17.65 46.95,17.11 48.57,17.11 49.16,17.7 56.8,17.7 59.05,15.44 59.05,13.09 60.02,12.12 v1(60.89,12.12)
  BOTTOM w0.102: R594.1 47.2,23.81 v1(46.39,23.81) ; R580.2 v1(60.89,12.12)
  BOTTOM w0.203: U42.33 R594.1
ESPI_CLK_R: length 117.9
  TOP w0.109: R437.2 148.94,49.59 v1(148.89,49.64)
  ART03 w0.102: v1(148.89,49.64) 148.84,49.7 148.84,52.72 147,54.55 134.4,54.55 133.96,54.12 129.47,54.12 125.83,50.48 118.05,50.48 117.81,50.23 111.47,50.23 110.73,50.98 108.08,50.98 107.21,50.11 101.52,50.11 99.71,51.92 89.9,51.92 88.77,50.79 79.15,50.79 77.47,52.48 66.48,52.48 65.62,51.62 56.7,51.62 55.85,52.47 51.3,52.47 v1(49.93,53.84)
  BOTTOM w0.109: U9.13 49.36,60.44 49.04,60.12 49.04,58.13 49.93,57.24 v1(49.93,53.84)
ESPI_CS_N_R: length 155.3
  TOP w0.076: 176.69,53.97 176.54,54.12 176.54,57.31 179.08,59.85 179.72,59.85 180.38,60.52 180.38,61.47 180.23,61.63 180.23,62.08 180.38,62.23 180.38,62.47 180.35,62.69 180.35,62.85 180.46,63.06 180.46,64.01 U1.CT45
  TOP w0.102: 176.69,53.97 176.69,52.94
  TOP w0.109: v1(153.21,49.66) 158.72,49.66 159.04,49.98 160.93,49.98 161.82,49.08 173.24,49.08 173.24,49.09 173.6,49.09 176.69,52.18 176.69,52.94
  ART03 w0.102: v1(57.19,52.09) 57.25,52.03 65.56,52.03 66.4,52.87 77.76,52.87 79.62,51 88.54,51 89.67,52.12 99.8,52.12 101.61,50.32 107.13,50.32 108,51.19 108.16,51.19 108.16,51.18 110.93,51.18 111.64,50.47 117.56,50.47 117.82,50.73 125.67,50.73 129.3,54.36 133.92,54.36 134.36,54.8 148.07,54.8 v1(153.21,49.66)
  BOTTOM w0.109: U9.6 52.16,60.82 54.09,58.89 54.75,58.89 57.19,56.44 v1(57.19,52.09)
ESPI_IO_0_R: length 117
  TOP w0.109: R433.1 v1(148.91,47.66)
  ART03 w0.102: v1(53.44,51.56) 55.23,49.77 66.3,49.77 67.51,50.97 76.64,50.97 77.73,49.87 89.52,49.87 90.64,51 99.14,51 100.95,49.19 118.36,49.19 118.84,49.67 126.42,49.67 129.52,52.77 136.27,52.77 137.12,53.62 145.42,53.62 146.69,52.35 146.69,49.14 148.18,47.66 v1(148.91,47.66)
  BOTTOM w0.109: v1(53.44,51.56) 53.44,57.46 51.4,59.51 51.4,59.76 50.56,60.6 U9.10
ESPI_IO_1_R: length 118.6
  TOP w0.109: R434.1 v1(148.47,48.09)
  ART03 w0.102: v1(148.47,48.09) 148.13,48.09 147.14,49.08 147.14,52.33 145.62,53.86 134.7,53.86 134.01,53.17 129.55,53.17 126.26,49.87 118.64,49.87 118.24,49.47 111.07,49.47 110.34,50.2 108.33,50.2 107.52,49.39 101.14,49.39 99.27,51.26 90.36,51.26 89.17,50.07 78.18,50.07 76.85,51.4 67.19,51.4 65.97,50.18 55.78,50.18 v1(54.17,51.79)
  BOTTOM w0.109: v1(54.17,51.79) 54.17,57.05 51.76,59.46 51.76,59.81 50.96,60.61 U9.9
ESPI_IO_2_R: length 115.9
  TOP w0.109: R435.1 148.76,48.57 v1(148.27,49.06)
  ART03 w0.102: v1(148.27,49.06) 147.93,49.39 147.93,52.74 146.6,54.07 134.58,54.07 134.01,53.49 129.45,53.49 126.03,50.08 118.39,50.08 118.03,49.71 111.21,49.71 110.42,50.5 108.31,50.5 107.44,49.63 101.38,49.63 99.51,51.5 90.24,51.5 89.05,50.32 78.65,50.32 77.14,51.83 66.9,51.83 65.86,50.79 55.91,50.79 54.99,51.71 v1(54.99,51.86)
  BOTTOM w0.109: v1(54.99,51.86) 54.99,56.57 52.07,59.5 52.07,59.93 51.36,60.64 U9.8
ESPI_IO_3_R: length 116.5
  TOP w0.109: v1(148.93,49.08) R436.1
  ART03 w0.102: v1(148.93,49.08) 148.82,49.08 148.28,49.62 148.28,52.78 146.75,54.31 134.45,54.31 134.01,53.88 129.52,53.88 125.92,50.28 118.3,50.28 117.96,49.94 111.36,49.94 110.56,50.73 108.19,50.73 107.36,49.9 101.45,49.9 99.63,51.72 90.11,51.72 88.98,50.59 78.75,50.59 77.17,52.17 66.82,52.17 65.89,51.25 56.33,51.25 v1(55.75,51.82)
  BOTTOM w0.109: U9.7 51.76,60.74 52.34,60.16 52.34,59.66 55.75,56.25 v1(55.75,51.82)
ESPI_RST_N: length 170.3
  TOP w0.076: 176.96,54.38 176.96,57.2 179.22,59.46 179.95,59.46 181.14,60.65 181.14,61.99 180.99,62.14 180.99,62.52 181.01,62.64 181.01,62.79 180.99,63.01 180.99,63.18 181.1,63.39 181.1,63.69 U1.CR46
  TOP w0.102: 176.96,54.38 177.18,54.16 177.18,52.94
  TOP w0.109: 177.18,52.94 177.18,51.51 174.28,48.61 161.29,48.61 160.98,48.92 153.42,48.92 v1(153.33,48.83)
  ART03 w0.102: v1(153.33,48.83) 152.46,48.83 150.55,46.92 148.44,46.92 146.45,48.91 146.45,51.7 144.75,53.4 138.44,53.4 137.3,52.26 129.35,52.26 126.56,49.47 119.08,49.47 118.6,48.99 100.78,48.99 99.05,50.72 91.44,50.72 90.3,49.58 77.25,49.58 76.35,50.48 67.86,50.48 66.69,49.31 55.13,49.31 53.9,50.53 47.31,50.53 43.79,54.05 43.79,55.79 v1(44.32,56.32)
  BOTTOM w0.109: v1(44.32,56.32) 44.29,56.35 R840.2 44.29,57.42 44.01,57.7 44.01,59.75 44.25,59.98 44.89,59.98 45.76,60.86 U9.22
EVDD10: length 37.9
  TOP w0.508: v1(71.48,67.13) 71.59,67.03 73.01,67.03 74.21,68.22 74.21,73.61 v1(74.14,73.68) 74.1,73.63 v1(71.52,73.63) 70.05,73.63 69.42,74.27 68.05,74.27 v1(67.69,73.91)
  ART06 w0.508: v1(64.08,64.78) 64.39,65.09 69.51,65.09 71.48,67.06 v1(71.48,67.13)
  BOTTOM w0.203: U30.3 v1(71.52,73.63) C434.1 ; v1(71.48,67.13) 71.45,67.16 71.45,67.34 71.52,67.42 U30.22 ; C424.1 74.23,73.77 v1(74.14,73.68) 73.52,73.06 U30.8 ; U30.30 69.58,71.33
  BOTTOM w0.305: C425.1 75.8,74.45 C428.1 C424.1 ; v1(71.48,67.13) 71.45,67.09 C437.2 71.45,66.42 C438.1 ; 69.58,71.33 68.84,71.33 67.74,72.43 C433.1 C426.1 67.12,73.67 67.36,73.91 v1(67.69,73.91)
FAN_BACK: length 11.9
  TOP w0.102: CN13.2 233.92,30.3 234.38,29.84 234.38,28.85 234.12,28.59 234.12,22.77 R558.2 233.31,21.17 R559.2 233.35,20.19 D25.P
FAN_PWMIN: length 256
  TOP w0.102: CN13.3 v1(231.92,31.3)
  ART06 w0.102: v1(231.92,31.3) 233.42,29.8 233.42,22.35 233.25,22.18 233.25,15.48 233.83,14.9 233.83,10.72 231.33,8.22 206.9,8.22 206.4,8.73 203.57,8.73 202.46,7.61 196.29,7.61 195.64,8.27 156.65,8.27 151.09,13.83 151.09,17.47 149.64,18.92 147.8,18.92 143.69,23.03 143.69,40.06 138.18,45.57 138.04,45.57 137.73,45.87 arc(137.7,45.91) 137.66,45.95 arc(135.27,47.51) 132.47,48.06 130.17,48.06 129.6,48.64 124.68,48.64 124.14,48.09 123.56,48.09 123.37,48.29 120.52,48.29 120.12,47.89 119.09,47.89 118.69,48.29 84.44,48.29 82.64,50.08 49.97,50.08 47.18,52.88 47.18,55.19 46.95,55.42 v1(45.77,55.42)
  BOTTOM w0.102: v1(45.77,55.42) 39.84,55.42 38.62,56.63 R339.1 38.63,57.75 R829.2
FAN_PWMIN_GPU: length 257.4
  ART06 w0.102: 116,54.2 114.52,52.72 111.43,52.72 111.01,53.14 105.89,53.14 105.26,52.52 101.28,52.52 100.29,53.51 85.95,53.51 84.42,51.98 69.88,51.98 68.21,53.66 56.22,53.66 55.88,53.32 v1(49.38,53.32) ; 138.31,49.87 148.17,40.01 151.33,40.01 152.75,38.59 152.75,38.1 153.47,37.39 153.47,34.73 152.99,34.25 152.99,29.81 153.58,29.21 153.58,14.97 156.98,11.57 184.44,11.57 185.23,10.77 186.52,10.77 187.34,11.6 213.57,11.6 214.75,10.41 228.19,10.41 228.67,10.9 228.67,13.47 230.94,15.73 230.94,19.41 231.88,20.34 231.88,29.89 v1(231.71,30.05)
  ART06 w0.114: 116,54.2 119.88,54.2 120.78,55.1 123.87,55.1 125.53,53.45 135.27,53.45 138.31,50.42 138.31,49.87
  BOTTOM w0.102: v1(231.71,30.05) 229.7,32.06 229.7,33.57 230.73,34.6 CN14.4 ; v1(49.38,53.32) 49.38,53.89 49.59,54.1 49.59,56.3 48.94,56.95 45.92,56.95 44.89,55.91 43.61,55.91 41.57,57.95 R345.1 41.57,58.39 R91.2
FB_CLAMP: length 249.1
  ART06 w0.102: v1(151.44,44.8) 145.04,44.8 139.63,50.21 139.63,50.69 135.55,54.77 127.61,54.77 125.65,56.73 116.48,56.73 115.18,55.43 111.6,55.43 110.39,54.23 105,54.23 104.48,53.71 102.03,53.71 101.14,54.6 82.77,54.6 81.41,53.24 80.14,53.24 78.51,54.86 74.05,54.86 73.17,55.74 53.8,55.74 50.72,58.83 50.72,64.11 46.67,68.16 44.7,68.16 43.09,69.78 43.09,71.31 42.28,72.11 42.28,76.75 41.32,77.72 41.32,79.94 v1(42.51,81.13)
  BOTTOM w0.102: CN14.3 222.53,34.2 222.21,34.52 222.21,35.04 221.9,35.34 208.12,35.34 206.13,37.33 189.83,37.33 188.01,35.51 182.48,35.51 180.16,33.19 155.43,33.19 151.44,37.17 v1(151.44,44.8) 150.42,45.82 150.42,53.88 150.19,54.11 150.19,54.6 149.25,55.54 149.25,56.95 148.57,57.62 148.57,59.12 148,59.69 148,63.28 148.36,63.64 148.36,66.35 149.04,67.03 R1390.1 ; R82.2 42.61,81.02 v1(42.51,81.13)
FB_CLAMP_C: length 3.2
  BOTTOM w0.102: R82.1 43.39,79.62 R322.1 43.4,79.01 44.16,78.26 U9.71
FLASH_SPI_CLK: length 170.9
  TOP w0.076: U1.DB42 177.45,65.89 v1(177.57,65.83)
  TOP w0.109: v1(157.16,56.51) 156.99,56.51 156.5,57 156.5,59.51 151.98,64.03 146.39,64.03 R724.1
  ART06 w0.087: v1(66.9,79.14) 66.77,79.02 66.77,78.46 67.41,77.82 82.3,77.82 83.12,78.64 83.12,81.8 86.18,84.85 86.18,89.85 88.5,92.18 121,92.18 126.13,87.05 126.77,87.05 134.27,79.55 134.27,67.63 138.18,63.72 139.72,63.72 144.56,58.88 144.56,57.92 145.83,56.65 146.1,56.65 154.22,56.65 154.36,56.51 v1(157.16,56.51)
  ART06 w0.102: v1(157.16,56.51) 160.98,56.51 161.24,56.26 161.84,56.26 162.41,56.83 167.88,56.83 168.88,57.83 170.51,57.83 172.96,60.28 174.66,60.28 175.4,61.01 175.4,62.03 176.66,63.28 176.66,64.48 177.07,64.89 177.07,64.98 177.07,65.16 177.07,65.33 v1(177.57,65.83)
  BOTTOM w0.075: v1(177.57,65.83) 177.28,66.12 R388.1
  BOTTOM w0.109: v1(66.9,79.14) 67.66,78.38 PR76.1
FLASH_SPI_CS#: length 191.4
  TOP w0.076: U1.DB43 177.39,65.28 177.42,65.26 v1(177.57,65.19)
  TOP w0.102: R721.2 132.17,65.28 132.57,64.89 U49_1.1 U49.1 ; 153.75,62.96 152.19,64.52 146.15,64.52 144.58,62.96
  TOP w0.109: U49.1 136.58,64.89 138.51,62.96 144.58,62.96 ; 153.75,62.96 157,59.71 157,57.33 157.7,56.63 157.7,56.22 v1(157.52,56.03)
  ART06 w0.102: v1(65.46,81.46) 65.46,78.77 66.9,77.33 82.77,77.33 83.74,78.31 83.74,81.72 86.66,84.64 86.66,89.58 88.78,91.7 120.75,91.7 125.88,86.57 126.58,86.57 133.8,79.35 133.8,67.43 135.33,65.9 135.33,65.77 137.86,63.24 139.53,63.24 144.07,58.69 144.07,57.73 145.63,56.18 149.68,56.18 150.3,55.55 150.78,55.55 151.11,55.88 153.86,55.88 154.05,55.69 156.85,55.69 157.19,56.03 v1(157.52,56.03) 159.25,56.03 159.96,55.33 160.98,55.33 161.41,55.75 162.02,55.75 162.57,56.3 163.62,56.3 163.95,55.97 166.15,55.97 166.63,55.48 167.62,55.48 169.57,57.43 170.44,57.43 173.03,60.02 174.73,60.02 175.62,60.9 175.62,61.91 177.7,63.98 177.7,65.07 v1(177.57,65.19)
  BOTTOM w0.102: R29.1 66.76,81.99 65.9,81.99 65.46,81.54 v1(65.46,81.46)
FLASH_SPI_D<2>: length 59.5
  TOP w0.075: U1.DF42 v1(175.74,65.83)
  TOP w0.102: R725.1 130.36,60.66 131.37,59.65 140.01,59.65 140.73,60.36 143.07,60.36 143.5,60.79 145.21,60.79 147.66,63.24 151.59,63.24 155.58,59.25 155.58,58.3 155.14,57.86 v1(155.09,57.86)
  ART06 w0.075: v1(175.74,65.83) 176.11,65.46 176.11,63.55
  ART06 w0.102: v1(155.09,57.86) 155.17,57.95 157.57,57.95 158.05,57.47 161.13,57.47 161.58,57.91 165.58,57.91 166.46,58.79 167.29,58.79 168.8,60.31 168.8,60.67 169.21,61.08 174.34,61.08 174.78,61.51 174.78,62.22 176.11,63.55
  BOTTOM w0.075: v1(175.74,65.83) 175.17,65.25 R176.2
FLASH_SPI_D<3>: length 46.1
  TOP w0.076: v1(176.66,66.46) 176.51,66.55 U1.DD41
  TOP w0.102: v1(157.41,57.56) 157.71,57.85 157.71,59.39 152.22,64.88 R726.1
  ART06 w0.102: v1(176.66,66.46) 176.28,66.09 176.28,63.47 175.01,62.2 175.01,61.37 174.4,60.75 172.17,60.75 170.84,59.42 168.5,59.42 167.65,58.58 166.57,58.58 165.61,57.61 161.59,57.61 161.23,57.25 157.72,57.25 v1(157.41,57.56)
  BOTTOM w0.075: R175.1 174.2,67.45 174.57,67.09 176.03,67.09 v1(176.66,66.46)
FLASH_SPI_MISO: length 169.3
  TOP w0.076: v1(176.66,65.18) 176.53,65.24 U1.DD43
  TOP w0.109: v1(154.38,57.77) 154.76,57.38 155.59,57.38 155.91,57.7 155.91,59.38 151.8,63.49 147.43,63.49 145.34,61.4 R728.1
  ART06 w0.087: v1(154.38,57.77) 153.92,57.77 153.27,57.12 146.09,57.12 145.04,58.17 145.04,59.11 143.02,61.13 143.02,61.41 139.6,64.83 139.04,64.83 138.2,65.67 137.17,65.67 134.74,68.1 134.74,79.11 134.74,79.79 126.91,87.62 126.22,87.62 121.19,92.65 88.29,92.65 85.68,90.04 85.68,85.1 82.37,81.78 82.37,79.15 81.54,78.32 67.82,78.32 67.43,78.72 67.43,79.25 67.12,79.56 66.42,79.56 66.21,79.35 v1(66.21,79.1)
  ART06 w0.102: v1(176.66,65.18) 176.46,64.98 176.46,63.36 175.22,62.11 175.22,61.17 174.57,60.52 172.81,60.52 170.58,58.3 169.63,58.3 169.26,58.67 168.83,58.67 167.49,57.33 161.67,57.33 161.35,57.01 155.91,57.01 155.6,57.33 154.82,57.33 v1(154.38,57.77)
  BOTTOM w0.109: v1(66.21,79.1) 66.21,79.02 66.87,78.36 PR72.1
FLASH_SPI_MOSI: length 184.5
  TOP w0.076: v1(175.74,65.18) 175.62,65.24 U1.DF43
  TOP w0.109: R727.1 130.03,63.51 129.63,63.11 129.63,60.57 130.82,59.38 140.21,59.38 140.85,60.02 143.08,60.02 143.6,60.54 145.4,60.54 147.86,63 151.48,63 154.31,60.18 154.31,59.37 v1(155.16,58.52)
  ART06 w0.087: v1(155.16,58.52) 150.86,58.52 149.79,57.45 146.1,57.45 145.26,58.29 145.26,59.2 143.46,61 143.46,61.75 139.94,65.26 138.95,65.26 138.14,66.07 137.71,66.07 135.3,68.47 135.3,79.88 122.32,92.86 88,92.86 85.41,90.28 85.41,85.15 82.02,81.76 82.02,79.26 81.31,78.55 68.05,78.55 67.72,78.89 67.72,80 v1(66.33,81.4)
  ART06 w0.102: v1(175.74,65.18) 175.74,63.56 174.26,62.08 172.45,62.08 171.9,61.53 168.83,61.53 168.55,61.25 168.19,61.25 165.15,58.22 161.54,58.22 161.06,57.74 158.11,57.74 157.67,58.19 155.49,58.19 v1(155.16,58.52)
  BOTTOM w0.109: v1(66.33,81.4) 66.49,81.56 67.51,81.56 67.75,81.8 PR75.1
FMISO: length 29.4
  BOTTOM w0.109: PR75.2 67.75,83.24 66.73,84.26 64.66,84.26 63.98,84.95 61.35,84.95 ; 61.2,84.8 61.2,84.81 ; 61.2,84.8 U36_S.2 ; 61.2,84.8 61.35,84.95 ; 61.2,84.81 61.06,84.95 ; 61.2,84.81 61.2,84.94 61.2,84.95 ; U9.103 54.91,73.65 54.2,74.36 54.2,76.55 54.72,77.07 54.72,80 53.91,80.81 53.91,84.13 55.07,85.29 60.72,85.29 61.06,84.95 ; 61.2,84.95 61.35,84.95 ; 61.2,84.95 61.06,84.95
FMOSI: length 16.9
  BOTTOM w0.109: U9.102 61.49,74.05 61.88,74.45 61.88,76.36 62.13,76.61 63.52,76.61 63.75,76.38 U36.5 63.75,74.46 63.96,74.25 64.56,74.25 66.87,76.56 PR72.2
FPS_INT_N: length 2.9
  TOP w0.075: 166.98,81.41 167.39,81.41 167.6,81.2 168.29,81.2 168.29,81.2 168.58,81.2 168.83,80.95 U1.DV11
  TOP w0.102: 166.98,81.41 166.53,81.41 R870.2
FSCE#: length 31.9
  BOTTOM w0.109: R29.2 66.95,83.54 66.58,83.91 64.51,83.91 63.9,84.52 62.22,84.52 61.84,84.15 61.84,81.55 61.49,81.2 60.2,81.2 59.94,81.47 U36.1 59.94,83.28 U36_S.1 59.93,83.98 60.26,84.31 60.26,84.83 60.05,85.04 55.32,85.04 54.24,83.96 54.24,80.91 55.01,80.14 55.01,76.81 54.46,76.26 54.46,74.74 54.75,74.45 U9.101
FSCK: length 15.8
  BOTTOM w0.109: 62.48,73.79 62.46,73.79 62.37,73.7 ; 62.48,73.79 62.57,73.7 ; 62.48,73.79 62.48,73.7 62.47,73.7 ; 62.48,73.79 U36.6 ; 62.57,73.7 64.71,73.7 67.66,76.65 PR76.2 ; 62.57,73.7 62.47,73.7 ; 62.37,73.7 61.84,73.7 61.7,73.55 56.98,73.55 56.28,72.85 U9.105 ; 62.37,73.7 62.47,73.7
GC6_FB_EN: length 250.5
  TOP w0.102: v1(151.92,40.59) 151.98,40.65 151.98,42.29 154.42,44.73 156.24,44.73 157.42,45.92 176.49,45.92 179.4,48.83 179.4,52.32 179.1,52.62 179.1,56.18 181.15,58.23 181.15,58.25 R125.2
  ART06 w0.102: v1(48.92,54.48) 49.08,54.64 73.19,54.64 74.01,53.82 78.41,53.82 79.71,52.52 83.04,52.52 84.48,53.96 100.54,53.96 101.51,52.99 104.9,52.99 105.51,53.6 111.8,53.6 112.01,53.38 114.55,53.38 115.93,54.75 116.93,54.75 118.11,55.94 125.32,55.94 127.17,54.08 135.35,54.08 138.82,50.62 138.82,50.01 145.62,43.21 148.51,43.21 151.13,40.59 v1(151.92,40.59)
  BOTTOM w0.102: R1391.2 37.81,62.59 38.49,61.9 38.49,59.59 38.12,59.22 38.12,56.77 39.89,54.99 42.62,54.99 44.19,53.42 47.86,53.42 v1(48.92,54.48) ; R421.2 219.68,38 219.52,37.83 218.18,37.83 217.56,37.22 208.74,37.22 206.99,38.96 188.78,38.96 187.18,37.36 181.83,37.36 179.59,35.12 156.69,35.12 156.48,35.33 154.58,35.33 153.41,36.5 153.41,37.52 151.76,39.17 151.76,40.43 v1(151.92,40.59)
GFX_CLK_REQ#: length 139.9
  TOP w0.076: v1(170.84,68.29) 170.84,68.34 170.86,68.35 170.86,68.41 U1.DP36
  TOP w0.102: R8.2 162.18,70.14 162.37,69.95 164,69.95 v1(164.17,69.78)
  ART03 w0.102: 172.35,69.79 171.03,69.79 170.8,70.02 165.56,70.02 165.03,69.49 164.47,69.49 v1(164.17,69.78) ; 172.35,69.79 172.5,69.79 ; 172.35,69.79 172.48,69.67 172.5,69.67 ; 172.5,69.67 172.5,69.46 172.05,69.02 171.57,69.02 v1(170.84,68.29) ; 172.5,69.67 172.5,69.79 ; 172.5,69.67 172.63,69.79 ; 172.5,69.79 172.63,69.79 ; 172.63,69.79 174.52,69.79 175.27,69.04 175.27,63.97 174.11,62.81 169.84,62.81 169,61.97 169,59.73 167.69,58.42 166.28,58.42 165.34,57.49 165.34,55.88 164.03,54.56 164.03,53.47 163.77,53.21 161.81,53.21 160.24,51.63 158.98,51.63 158.61,51.26 158.61,50.01 157.51,48.91 157.51,46.36 154.72,43.57 154.72,38.67 v1(153.01,36.95)
  BOTTOM w0.102: 207.43,36.62 208.17,35.87 218.55,35.87 219.3,36.62
  BOTTOM w0.114: 207.43,36.62 206.3,37.74 189.58,37.74 187.94,36.11 182.43,36.11 179.93,33.61 155.85,33.61 153.01,36.45 v1(153.01,36.95) ; CN14.7 222.66,35.8 221.83,36.62 219.3,36.62
GFX_PCIE_CLK_N: length 143.1
  TOP w0.076: U1.CK3 182.79,85.14 182.71,85.22 182.71,85.4 182.81,85.49 182.89,85.49 182.95,85.56 182.95,85.7 182.83,85.82 182.83,86.63 182.25,87.21 182.25,88.12 182.46,88.33 182.52,88.33 v1(182.86,88.67)
  ART03 w0.075: 176.86,54.24 176.95,54.33 176.95,54.36 177.61,55.01 177.61,56.56 183.58,62.54 183.58,78.15 183.35,78.39 183.35,81.46 183.69,81.81 184.41,81.81 184.76,82.15 184.76,84.05 184.85,84.15 184.85,85.1 183.81,86.14 183.81,87.88 183.27,88.43 183.1,88.43 v1(182.86,88.67)
  ART03 w0.087: v1(156.17,34.32) 156.93,34.32 176.86,54.24
  BOTTOM w0.109: CN14.11 222.52,37.4 222.39,37.53 222.01,37.53 221.59,37.12 218.71,37.12 218.03,36.43 208.43,36.43 206.6,38.26 189.23,38.26 187.57,36.6 182.16,36.6 179.96,34.4 156.25,34.4 v1(156.17,34.32)
GFX_PCIE_CLK_P: length 143.1
  TOP w0.076: v1(182.86,88.03) 182.72,88.17 182.53,88.17 182.41,88.05 182.41,87.28 183,86.7 183,85.89 183.12,85.77 183.12,85.37 183.23,85.26 183.23,85.02 182.94,84.73 U1.CK4
  ART03 w0.075: v1(182.86,88.03) 183.1,88.28 183.21,88.28 183.66,87.82 183.66,86.08 184.7,85.04 184.7,84.21 184.61,84.11 184.61,82.21 184.35,81.96 183.63,81.96 183.2,81.53 183.2,78.32 183.43,78.09 183.43,62.61 177.45,56.63 177.45,55.08 176.82,54.44 176.8,54.44 176.73,54.37
  ART03 w0.087: v1(156.17,34.92) 156.59,34.5 156.85,34.5 176.73,54.37
  BOTTOM w0.109: v1(156.17,34.92) 156.47,34.61 179.87,34.61 182.07,36.82 187.48,36.82 189.14,38.48 206.69,38.48 208.52,36.65 217.94,36.65 218.62,37.33 221.5,37.33 221.92,37.76 222.31,37.76 222.75,38.2 CN14.13
GPD_7: length 11.7
  TOP w0.075: U1.DC47 176.4,63.64 176.68,63.37 176.68,62.73 176.81,62.59 176.81,62.21 177.07,61.94 177.07,60.56 174.13,57.62 174.13,55.94 173.57,55.38 172.96,55.38
  TOP w0.102: 172.96,55.38 172.87,55.38 R865.2 172.19,54.7 R866.1
GPP_C_5_SML0ALERTB: length 12.8
  TOP w0.076: v1(170.87,74.83) 171.21,75.26 U1.DP22
  TOP w0.102: R644.1 160.29,76.14 v1(160.14,76)
  ART03 w0.102: v1(170.87,74.83) 170.87,74.85 170.79,74.93 168.65,74.93 167.84,75.74 162.34,75.74 161.82,76.25 160.4,76.25 v1(160.14,76)
GPP_E11: length 9.4
  TOP w0.075: U1.DV16 168.77,78.64 167.9,78.64 167.8,78.74 167.24,78.74 166.74,79.23
  TOP w0.102: PR29.1 161.36,79.39 PR30.2 161.5,80.29 163.77,80.29 164.83,79.23 166.74,79.23
GPP_E12: length 7.5
  TOP w0.075: 164.91,78.9 164.91,78.43 165.14,78.19 166.14,78.19 166.52,78.57 167.61,78.57 167.85,78.33 U1.DW16
  TOP w0.102: 164.91,78.9 163.97,79.84 PR56.2 162.2,79.84 PR37.1
GPP_J_0_CNV_GNSS_PA_BLANKING: length 75.1
  TOP w0.076: v1(170.91,72.14) 170.91,72.14 U1.DP29
  TOP w0.102: v1(127.64,96.76) 127.64,96.78 127.66,96.8 128.1,96.8 128.52,97.22 R263.1
  ART06 w0.102: v1(170.91,72.14) 170.09,72.96 169.12,72.96 168.69,73.39 166.98,73.39 166.62,73.75 164.5,73.75 163.31,72.56 159.22,72.56 158.59,73.19 156.08,73.19 152.37,76.9 152.37,84.65 149.8,87.22 149.8,94.99 149.06,95.73 145.68,95.73 142.51,98.9 142.51,101.19 141.06,102.64 128.22,102.64 127.61,102.03 127.61,101.12 127.14,100.64 127.14,97.32 127.5,96.96 127.5,96.76 v1(127.64,96.76)
GPP_J_8_CNV_MFUART2_RXD: length 72.4
  TOP w0.102: U1.DT40 169.71,67.55 164.21,67.55 164.06,67.7 164.06,68.42 163.05,69.43 161.44,69.43 161.3,69.57 160.82,69.57 160.44,69.94 v1(160.44,69.98) ; v1(127.29,96.32) 127.76,95.85 128.42,95.85 R274.1
  ART06 w0.102: v1(160.44,69.98) 160.18,69.71 158.86,69.71 158.09,70.47 158.09,71.64 157.68,72.05 156.07,72.05 151.51,76.61 151.51,84.12 148.35,87.28 148.35,91.81 141.5,98.66 141.5,100.95 140.66,101.78 131.96,101.78 129.22,99.04 129.22,96.79 128.35,95.92 127.76,95.92 127.47,96.21 127.31,96.21 127.29,96.22 v1(127.29,96.32)
GPP_J_9_CNV_MFUART2_TXD: length 69.5
  TOP w0.102: v1(159.88,70.27) 159.88,69.84 160.41,69.31 161.18,69.31 161.28,69.22 162.97,69.22 163.88,68.3 163.88,67.62 164.15,67.35 168.6,67.35 U1.DW40 ; v1(128.02,96.31) 128.05,96.28 128.5,96.28 R264.1
  ART06 w0.102: v1(159.88,70.27) 159.54,69.93 158.98,69.93 158.41,70.5 158.41,71.66 157.79,72.29 156.12,72.29 151.72,76.69 151.72,84.25 148.72,87.25 148.72,91.73 141.74,98.71 141.74,101.01 140.75,101.99 131.45,101.99 128.65,99.2 128.65,96.94 v1(128.02,96.31)
GPPC_B0_CORE_VID0_R: length 85.2
  BOTTOM w0.102: R216.2 181.44,61.26 180.83,60.65 178.74,60.65 176.56,58.46 176.56,56.62 174.98,55.04 172.54,55.04 ; 165.26,56.01 165.26,54.84 166.96,53.14 168.13,53.14
  BOTTOM w0.127: 159.84,81.77 157.9,81.77 157.29,82.38 154.83,82.38 154.41,81.95 U56.1 154.41,80.02 151.6,77.21 151.6,75.83 150.4,74.62 150.4,73.25 151.04,72.61 154.02,72.61 155.39,71.24 155.39,70.51 156.8,69.1 156.8,67.06 157.01,66.86 157.01,65.44 156.46,64.89 156.46,62.52 159,59.98 161.68,59.98 162.63,59.03 162.63,58.29 163.53,57.38 163.89,57.38 165.26,56.01 ; 172.54,55.04 170.64,53.14 168.13,53.14
  BOTTOM w0.203: U6.18 164.85,93.55 R326.2 164.67,93.38 164.21,92.91 164.21,91.54 R316.1 ; R316.1 163.79,91.27 162.9,91.27 161.95,90.32 161.95,87.76 163.51,86.2 163.51,84.01 161.28,81.77 159.84,81.77 ; R316.1 R317.2
GPPC_B0_CORE_VID_0: length 6.7
  TOP w0.076: v1(183.06,67.73) U1.CL38
  BOTTOM w0.075: v1(183.06,67.73) 182.71,67.38 182.71,64.03 182.58,63.91 182.58,63.28 R216.1
GPPC_B1_CORE_VID1_R: length 87.3
  ART03 w0.127: v1(158.46,82.3) 159.38,81.39 161.83,81.39 162.5,82.06 164.68,82.06 165.31,82.68 166.14,82.68 167.81,84.35 167.81,86.71 v1(168.08,86.98)
  BOTTOM w0.102: 162.25,58.17 162.25,57.84 164.85,55.24 164.85,54.95 166.94,52.86 170.74,52.86 172.69,54.81 175.05,54.81 176.73,56.5 176.73,58.39 178.59,60.24 R231.2
  BOTTOM w0.127: 162.25,58.17 162.25,58.86 161.38,59.73 158.8,59.73 156.12,62.41 156.12,64.99 156.72,65.59 156.72,66.53 156.56,66.68 156.56,68.86 154.96,70.46 154.96,71.22 153.87,72.32 150.91,72.32 150.09,73.14 150.09,74.65 151.35,75.91 151.35,77.34 153.76,79.75 U56.2 153.76,82.03 154.38,82.66 158.1,82.66 v1(158.46,82.3)
  BOTTOM w0.203: U6.17 165.25,93.68 R318.2 166.08,92.84 166.08,91.52 R310.1 ; R310.1 166.51,91.22 167.52,90.21 167.52,89.38 168.12,88.78 168.12,87.02 v1(168.08,86.98) ; R310.1 R313.2
GPPC_B1_CORE_VID_1: length 10.2
  TOP w0.076: U1.CJ38 v1(183.98,67.73)
  BOTTOM w0.075: R231.1 181.25,60.24 182.14,61.13 182.14,62.18 184.35,64.39 184.35,67.44 184.05,67.73 v1(183.98,67.73)
GPPC_B2_UART_BT_WAKE#: length 83.9
  TOP w0.075: R877.2 164.11,66.74 163.7,67.16
  TOP w0.102: CN22.20 131.73,103.86 130.68,102.81 R4.2 128.89,103.54 126.16,103.54 R420.1 124.99,102.37 124.99,98.88 124.19,98.08 124.19,96.55 124.68,96.07 126.04,96.07 126.34,96.36 v1(126.36,96.36) ; 163.7,67.16 163.33,67.53 163.33,68.22 162.91,68.64 160.92,68.64 160.8,68.77 159.99,68.77 v1(159.92,68.7)
  ART06 w0.102: v1(159.92,68.7) 159.69,68.7 159.6,68.78 159.26,68.78 157.13,70.91 156.92,70.91 151.27,76.56 151.27,83.99 148.04,87.22 148.04,91.8 141.27,98.57 141.27,100.86 140.56,101.57 132.54,101.57 129.87,98.91 129.87,96.89 128.58,95.6 126.71,95.6 126.47,95.84 126.47,96.25 v1(126.36,96.36)
GPPC_B2_VRALERT_N: length 4.2
  TOP w0.076: v1(182.16,67.73) 182.13,67.76 182.1,67.76 U1.CN38
  BOTTOM w0.075: v1(182.16,67.73) 181.72,67.3 181.72,65.66 181.18,65.11 R233.1
GPPC_B2_VRALERT_N_R: length 18.3
  BOTTOM w0.075: R233.2 181.18,63.45 180.66,62.93 178.69,62.93 177.67,61.91 R831.1 177.04,61.71 R832.2
  BOTTOM w0.102: D67.N 169.93,54.4 170.76,54.4 172.06,55.69 174.76,55.69 175.98,56.91 175.98,59.12 177.04,60.18 R832.2
GPPC_H_18_CPU_C10_GATE_N_R: length 29.8
  TOP w0.076: 161.97,69.01 162.91,69.01 163.71,68.21 163.71,67.54 164.09,67.16 168.2,67.16 168.44,66.93 169.14,66.93 U1.DU40
  TOP w0.102: 161.97,69.01 161.09,69.01 161,69.1 159.75,69.1 159.32,68.67 159.32,68.47 159.13,68.28 158.23,68.28 158.01,68.5 156.31,68.5 156.1,68.28 v1(155.38,68.28)
  BOTTOM w0.102: v1(155.38,68.28) 155.37,68.28 154.5,67.41 154.5,61.95 157.45,59 157.45,58.56 158.65,57.36 R354.1
GPU_ALL_PWRGD: length 118.5
  TOP w0.102: v1(152.47,37.51) 152.47,37.95 153.61,39.09 153.61,42.8 154.59,43.78 158.28,43.78 158.87,44.37 160.22,44.37 160.82,43.77 176.01,43.77 180.33,48.1 180.33,52.48 179.56,53.25 179.56,55.59 179.97,56 180.22,56 181.76,57.54 R142.2
  BOTTOM w0.102: v1(152.47,37.51) 152.47,36.55 155.63,33.39 180.05,33.39 182.45,35.8 187.98,35.8 189.72,37.54 206.22,37.54 208.21,35.55 218.89,35.55 219.36,36.02 R221.1
GPU_EVENT: length 172.6
  TOP w0.102: v1(155.51,43.09) 155.51,43.13 155.81,43.43 176.46,43.43 180.74,47.71 180.74,52.52 179.81,53.46 179.81,55.56 179.99,55.74 180.58,55.74 R144.2 ; R510.2 v1(232.79,41.44)
  ART06 w0.102: v1(232.79,41.44) 232.14,41.44 231.75,41.04 231.75,33.11 230.61,31.97 230.61,28.63 230.89,28.35 230.89,21 229.81,19.92 229.81,18.14 228.75,17.08 228.75,14.58 226.48,12.32 157.7,12.32 155.11,14.91 155.11,17.02 156.45,18.36 156.45,25.23 155.29,26.39 155.29,28.93 156.71,30.35 156.71,36.23 155.28,37.65 155.28,42.87 v1(155.51,43.09)
GPU_PWR_EN: length 114.2
  TOP w0.102: R143.2 179.32,55.74 179.32,52.93 179.92,52.33 179.92,48.79 176.71,45.58 158.41,45.58 157.08,44.26 154.53,44.26 152.46,42.18 152.46,40.24 152.71,39.99 v1(152.71,39.68)
  BOTTOM w0.102: v1(152.71,39.68) 153.06,39.68 154.09,38.64 154.09,37 155.1,36 156.91,36 157.05,35.85 179.14,35.85 181.52,38.23 186.57,38.23 188.24,39.9 207.44,39.9 209.11,38.23 216.15,38.23 217.59,39.67 219.18,39.67 R509.2
GPU_PWR_EN_EC: length 204.7
  ART06 w0.102: v1(49.06,64.2) 49.74,63.52 49.74,59.62 49.29,59.18 49.29,55.93 49.97,55.26 72.89,55.26 74.1,54.06 78.61,54.06 79.85,52.82 81.66,52.82 83.01,54.17 100.88,54.17 101.76,53.29 104.72,53.29 105.25,53.81 110.68,53.81 111.85,54.98 115.4,54.98 116.56,56.15 125.5,56.15 127.34,54.31 135.42,54.31 139.08,50.64 139.08,50.11
  ART06 w0.114: 139.08,50.11 145.06,44.13 149.21,44.13 v1(152.96,40.37)
  BOTTOM w0.102: U9.113 54.2,69.65 53.68,69.13 53.68,68.21 49.67,64.2 v1(49.06,64.2) ; v1(152.96,40.37) 152.96,40.23 154.3,38.89 154.3,37.32 155.41,36.21 156.98,36.21 157.14,36.05 178.97,36.05 181.35,38.43 186.49,38.43 188.16,40.1 207.52,40.1 209.19,38.43 216.04,38.43 217.5,39.89 219.79,39.89 R426.2
GPU_RST_EC: length 281.5
  TOP w0.114: v1(232.53,40.93) 232.39,40.8 232.2,40.8 231.05,41.95 231.05,43.42 230.9,43.57 230.36,43.57 229.74,44.2 229.74,48.76 R516.1
  ART06 w0.102: v1(232.53,40.93) 232.57,40.89 232.57,40.53 232.11,40.07 232.11,33.12 230.88,31.89 230.88,29.12 231.16,28.83 231.16,20.76 230.34,19.93 230.34,15.89 226.57,12.12 157.62,12.12 154.91,14.83 154.91,17.24 156.12,18.45 156.12,25.12 154.91,26.33 154.91,29.16 155.43,29.68 155.43,34.04 154.9,34.57 154.9,44.32 154.29,44.93 154.29,45.93 155,46.64 155,47.26 154.59,47.67 154.28,47.67 154.26,47.65 154.25,47.65 154.03,47.43 150.36,47.43 150.15,47.23 148.55,47.23 142.47,53.3 138.87,53.3 135.32,56.85 127.79,56.85 125.95,58.68 123.45,58.68 122.78,59.35 121.11,59.35 120.16,58.41 114.76,58.41 114.13,57.78 113.28,57.78 113.23,57.73 113.22,57.73 112.78,57.28 108.01,57.28 107.49,57.8 103.78,57.8 101.26,60.32 94.27,60.32 92.05,58.1 77.18,58.1 76.09,59.19 72.54,59.19 72.23,58.88 60.9,58.88 58.53,61.26 53.4,61.26 52,62.66 52,64.74 51.52,65.21 51.52,66.66 49.94,68.25 v1(48.51,68.25)
  BOTTOM w0.102: U9.84 49.36,76.86 49.43,76.79 49.43,75.7 49.16,75.43 49.16,74.53 49.75,73.94 49.75,68.88 49.11,68.25 v1(48.51,68.25)
H_CATERR_3P3V_N: length 216.8
  TOP w0.102: U13.4 218.82,90.63 R373.2 218.07,92.13 211.85,92.13 211.36,91.64 v1(211.36,91.49)
  ART03 w0.075: v1(211.36,91.49) 209.78,89.91 209.78,89.63 208.47,88.31 208.47,86.49 207.45,85.47 205.23,85.47 204.23,86.46 202.71,86.46 201.13,88.05 201.13,89.98 197.81,93.3 197.81,95.42 196.57,96.65 192.33,96.65 191.41,97.57
  ART03 w0.102: 191.41,97.57 189.65,99.33 189.65,102.26 186.55,105.37 175.58,105.37 174.23,106.72 167.85,106.72 167.27,107.3 165.07,107.3 164.47,106.71 164.42,106.71 164.41,106.69 157.66,106.69 157.43,106.93 149.81,106.93 149.2,106.32 141.5,106.32 139.47,104.29 139.47,103.98 138.84,103.35 131.82,103.35 130.97,104.2 130.97,105.25 129.89,106.32 123.99,106.32 123.28,105.61 114.78,105.61 110.73,101.56 106.13,101.56 105.41,100.83 105.41,98.28 106.3,97.39 106.3,95.13 103.48,92.31 90.83,92.31 89.4,90.88 89.4,80.77 86.97,78.34 80.25,78.34 80.01,78.09 61.45,78.09 61.01,77.65 57.6,77.65 57.34,77.39 55.97,77.39 55.28,76.7 49.12,76.7 v1(48.96,76.54)
  BOTTOM w0.102: U9.83 v1(48.96,76.54)
H_PECI_EC: length 171.8
  TOP w0.076: U1.CD5 185.93,84.16 185.75,84.35 185.75,84.63 185.69,84.69 185.69,85 185.7,85.02 185.7,85.26 185.62,85.34 185.62,86.39 v1(185.83,86.6)
  TOP w0.102: R237.2 56.75,73.81 v1(57.5,74.56)
  ART03 w0.075: v1(185.83,86.6) 185.83,86.79 185.14,87.48 185.14,89.81 184.51,90.45 184.51,93.37 184.83,93.69 184.83,97.57
  ART03 w0.102: v1(57.5,74.56) 57.77,74.56 58.41,75.21 59.62,75.21 59.98,75.57 64.05,75.57 65.24,76.76 80.23,76.76 80.76,76.23 80.76,75.85 81.18,75.43 85.44,75.43 86.75,74.12 91.74,74.12 103.94,86.32 103.94,89.86 117.85,103.77 124.66,103.77 124.99,104.11 128.37,104.11 130.93,101.55 140.27,101.55 141.42,102.71 141.42,103.63 142.28,104.49 150.07,104.49 150.45,104.87 163.48,104.87 163.86,104.48 165.64,104.48 165.87,104.25 174.12,104.25 174.86,103.51 181.71,103.51 184.83,100.39 184.83,97.57
HDA_BITCLK: length 146.9
  TOP w0.109: U25.6 34.6,80.05 34.78,80.23 37.08,80.23 38.08,79.23 C488.2 38.6,79.12 39.75,77.97 39.75,67.95 41.39,66.31 43.34,66.31 47.58,62.07 47.58,59.65 47.04,59.11 47.04,55.34 v1(46.66,54.96) ; R266.1 151.83,56.05 150.66,56.05 v1(150.62,56.01)
  ART03 w0.087: v1(150.62,56.01) 150.24,56.01 149.89,56.36 133.75,56.36 133.2,55.81 128.7,55.81 125.03,52.15 119.75,52.15 118.55,53.36 117.39,53.36 116.8,52.76 115.55,52.76 115.11,52.33 111.83,52.33 111.5,52.65 107.47,52.65 107.27,52.45 107.26,52.45 106.53,51.73 102.19,51.73 100.38,53.53 83.21,53.53 82.34,52.66 80.12,52.66 77.88,54.9 66.14,54.9 65.12,53.88 57.23,53.88 56.86,54.25 54.02,54.25 52.92,55.35 47.05,55.35 v1(46.66,54.96)
HDA_RST#: length 126.3
  TOP w0.109: v1(151.28,57.77) 151.68,57.77 R278.1 ; R371.1 R390.2 37.49,59.33 37.49,57.45 40.06,54.88 v1(44.32,54.88)
  ART03 w0.087: v1(44.32,54.88) 45.79,56.36 46.74,56.36 47.28,56.89 49.92,56.89 50.51,56.3 53.74,56.3 54.2,55.84 78.61,55.84 79.98,54.47 100.79,54.47 102.48,52.78 105.04,52.78 105.41,53.15 105.44,53.15 106.63,53.15 106.87,53.39 106.88,53.39 107.09,53.6 111.88,53.6 112.21,53.26 114.62,53.26 115.65,54.3 119.28,54.3 120.47,53.12 123.92,53.12 128.22,57.42 132.93,57.42 133.66,58.15 138.45,58.15 139.14,58.84 144.5,58.84 145.77,57.57 151.08,57.57 v1(151.28,57.77)
HDA_SDATAIN0: length 152.2
  TOP w0.109: C430.2 39.27,81.7 40.26,80.71 40.26,68.36 41.81,66.8 44.33,66.8 45.66,65.47 45.66,64.84 48.09,62.41 48.09,58.97 47.95,58.83 47.95,55.01 47.31,54.37 v1(46.68,54.37) ; R26.1 v1(151.56,54.26)
  TOP w0.127: U25.8 34.21,80.85 34.97,81.6 37.7,81.6 38.06,81.24 38.65,81.24 C430.2
  ART03 w0.087: v1(151.56,54.26) 150.55,54.26 148.93,55.87 133.93,55.87 133.36,55.31 128.87,55.31 125.24,51.68 119.32,51.68 119.04,51.96 116.49,51.96 116.05,51.52 113.92,51.52 113.57,51.86 111.63,51.86 111.37,52.13 108.56,52.13 107.61,52.13 107.46,51.98 107.45,51.98 107,51.53 106.73,51.26 102,51.26 100.19,53.07 83.51,53.07 82.62,52.18 79.93,52.18 77.74,54.38 66.29,54.38 65.15,53.24 56.77,53.24 56.38,53.64 53.72,53.64 52.47,54.89 47.61,54.89 47.09,54.37 v1(46.68,54.37)

# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_A5: length 79.1
  TOP w0.076: U1.BG48 194.07,62.67 194.07,62.62 194.12,62.57 194.15,62.51 194.15,62.19 194.16,62.17 194.16,61.46 194.15,61.45 194.15,61.31 194.03,61.19 194.03,58.5 194.45,58.07 194.45,56.69 v1(194.86,56.29)
  TOP w0.155: v1(190.34,30.51) 190.34,30.68 190.47,30.81 CN11.126
  ART06 w0.108: v1(190.34,30.51) 190.47,30.38 190.47,29.81 190.35,29.69 189.78,29.69 189.54,29.45 189.54,28.83 189.65,28.73 190.2,28.73 190.31,28.62 190.31,28.4 190.2,28.3 189.65,28.3 189.54,28.19 189.54,27.54 191.27,25.82 193.28,25.82 194.2,26.74 194.2,30.68 194.1,30.78 194.1,31.29 194.27,31.46 195.12,31.46 196.84,33.17 196.84,34.03 198.47,35.66 198.47,36.25 199.43,37.21 199.43,37.52 199.67,37.76 200.92,37.76 201.03,37.65 201.03,37.43 200.92,37.32 200.06,37.32 199.95,37.21 199.95,37 200.06,36.89 201.36,36.89 201.45,36.8 201.45,36.58 201.33,36.46 199.31,36.46 199.22,36.37 199.22,36.15 199.34,36.03 201.54,36.03 201.92,36.41 201.92,37.48 201.15,38.26 201.15,42.77 201.26,42.88 201.48,42.88 201.58,42.77 201.58,38.45 201.69,38.34 201.91,38.34 202.02,38.45 202.02,41.86 202.12,41.97 202.34,41.97 202.45,41.86 202.45,41.56 202.55,41.46 202.76,41.46 202.88,41.58 202.88,42.1 196.41,48.56 196.41,50.55 195.6,51.37 195.6,56.07 195.38,56.29 v1(194.86,56.29)
M_A_A6: length 78.5
  TOP w0.075: 196.72,55.29 196.97,55.05
  TOP w0.076: 196.72,55.29 196.72,57.48 196.17,58.03 196.17,61.05 196.17,61.05 196.17,61.11 196.17,61.12 196.17,61.98 196.02,62.13 196.02,62.16 196,62.18 196,62.55 196.02,62.56 196.02,62.6 196.03,62.61 196.03,62.71 196.02,62.72 196.02,62.83 196.02,62.84 196.02,62.85 196.01,62.86 195.99,62.95 195.99,63.12 196.02,63.21 196.02,63.54 196.08,63.6 196.08,64.14 195.89,64.33 U1.BE45
  TOP w0.135: v1(196.2,52.95) 196.56,52.59 196.56,49.7 197.08,49.17 199.8,49.17 199.97,49.01 199.97,48.74 199.87,48.64 197.89,48.64 197.78,48.52 197.78,48.25 197.93,48.1 199.8,48.1 199.97,47.93 199.97,47.66 199.87,47.56 197.89,47.56 197.78,47.44 197.78,47.17 197.93,47.02 200.39,47.02 200.65,47.28 200.65,50.35 199.72,51.28 198.96,51.28 198.42,51.82 198.42,52.53 196.97,53.99 196.97,55.05
  TOP w0.254: v1(190.59,25.47) 190.59,25.33 190.72,25.19 CN11.127
  ART06 w0.108: v1(190.59,25.47) 190.76,25.3 193.69,25.3 194.85,26.46 194.85,29.55 198.47,33.16 199.37,33.16 201.39,35.18 201.58,35.18 202.6,36.2 202.6,37.66 203.55,38.61 203.55,42.32 197.04,48.83 197.04,50.55 196.65,50.94 196.65,52.61 196.31,52.95 v1(196.2,52.95)
M_A_A7: length 79.5
  TOP w0.076: v1(194.86,56.91) 195.05,57.11 195.05,57.79 194.28,58.57 194.28,61.09 194.31,61.13 194.31,61.38 194.33,61.39 194.33,62.24 194.31,62.25 194.31,62.61 194.28,62.64 194.24,62.73 194.24,63.8 193.92,64.12 U1.BG45
  TOP w0.135: CN11.122 189.47,30.24 189.63,30.09 190.5,30.09 190.64,29.95 190.64,29.66 190.55,29.58 189.27,29.58 v1(189.14,29.45)
  ART06 w0.108: v1(189.14,29.45) 189.22,29.37 189.22,29.09 189.12,28.98 188.59,28.98 188.49,28.87 188.49,28.66 188.59,28.55 189.12,28.55 189.22,28.44 189.22,28.22 189.12,28.12 188.59,28.12 188.49,28.01 188.49,27.79 188.59,27.68 189.12,27.68 189.22,27.58 189.22,27.37 191.04,25.56 193.49,25.56 194.52,26.59 194.52,30.46 194.69,30.64 194.9,30.64 195.12,30.42 195.28,30.42 195.43,30.57 195.43,30.72 195.21,30.94 195.21,31.1 195.36,31.25 195.51,31.25 195.73,31.03 195.89,31.03 196.04,31.18 196.04,31.33 195.82,31.55 195.82,31.71 195.97,31.86 196.12,31.86 196.34,31.64 196.5,31.64 196.65,31.79 196.65,31.95 196.43,32.17 196.43,32.32 196.58,32.47 196.73,32.47 196.96,32.25 197.11,32.25 197.26,32.4 197.26,32.56 196.97,32.84 196.97,33.03 197.18,33.24 197.34,33.24 197.57,33.01 197.77,33.01 198.14,33.38 198.14,33.59 197.59,34.14 197.59,34.27 197.82,34.5 197.97,34.5 198.55,33.92 198.7,33.92 198.86,34.07 198.86,34.22 198.28,34.8 198.28,34.95 198.93,35.61 200.29,35.61 200.4,35.5 200.4,35.29 200.29,35.18 199.04,35.18 198.93,35.07 198.93,34.85 199.04,34.75 199.53,34.75 199.64,34.64 199.64,34.24 199.75,34.14 199.97,34.14 200.07,34.24 200.07,34.64 200.18,34.75 200.64,34.75 200.83,34.94 200.83,35.5 200.94,35.61 201.57,35.61 202.27,36.31 202.27,37.82 203.22,38.77 203.22,40.37 203.11,40.48 202.89,40.48 202.78,40.37 202.78,38.99 202.68,38.88 202.46,38.88 202.35,38.99 202.35,40.8 202.46,40.91 203.11,40.91 203.22,41.02 203.22,42.2 196.73,48.69 196.73,50.59 195.78,51.53 195.78,56.64 195.51,56.91 v1(194.86,56.91)
M_A_A8: length 78.7
  TOP w0.076: U1.BG47 193.68,63.18 193.68,62.88 193.7,62.78 193.7,62.61 193.68,62.5 193.68,62.21 193.82,62.07 193.82,62.05 193.83,62.03 193.83,61.6 193.82,61.58 193.82,61.45 193.7,61.33 193.7,61.06 193.7,58.63 193.7,58.5 193.7,58.36 194.12,57.93 194.12,56.46 194.28,56.31 194.28,54.97 v1(194.84,54.41)
  TOP w0.135: v1(190.96,27.14) 190.65,27.44 189.89,27.44 189.67,27.22 189.67,25.68 190.22,25.13 CN11.125
  ART06 w0.108: v1(194.84,54.41) 195.06,54.41 195.23,54.24 195.23,51.11 195.79,50.55 195.79,48.28 200.31,43.76 200.31,38.53 200.2,38.42 199.99,38.42 199.88,38.53 199.88,43.58 199.75,43.71 199.53,43.71 199.45,43.63 199.45,38.56 199.36,38.47 199.14,38.47 199.01,38.6 199.01,44.47 198.89,44.6 198.68,44.6 198.58,44.5 198.58,39.08 197.75,38.24 197.75,37.99 197.86,37.88 198.66,37.88 198.77,37.77 198.77,37.56 198.66,37.45 197.86,37.45 197.75,37.34 197.75,35.86 195.97,34.08 195.97,33.93 196.23,33.66 196.23,33.51 196.08,33.36 195.93,33.36 195.66,33.62 195.51,33.62 195.36,33.47 195.36,33.32 195.62,33.05 195.62,32.9 195.47,32.75 195.32,32.75 195.05,33.01 194.9,33.01 194.75,32.86 194.75,32.71 195.01,32.44 195.01,32.28 194.86,32.14 194.71,32.14 194.45,32.39 194.28,32.39 193.37,31.49 193.37,30.58 193.55,30.4 193.55,27.05 192.84,26.34 191.75,26.34 v1(190.96,27.14)
M_A_A9: length 78.6
  TOP w0.076: U1.BE47 194.94,63.68 194.85,63.59 194.85,62.79 194.74,62.54 194.74,61.38 195.32,60.79 195.32,58.23 195.27,58.18
  TOP w0.135: v1(196.2,54.79) 195.88,54.79 195.75,54.65 195.75,51.9 196.15,51.5 196.15,49.59 196.52,49.22 196.52,46.53 196.39,46.4 195.2,46.4 195.07,46.54 195.07,47.59 195.2,47.72 195.89,47.72 196,47.84 196,48.11 195.85,48.26 195.2,48.26 195.07,48.4 195.07,48.67 195.2,48.8 195.65,48.8 195.79,48.94 195.79,49.21 195.65,49.34 195.2,49.34 195.07,49.48 195.07,49.95 195.27,50.16 195.27,58.18
  TOP w0.155: CN11.121 189.22,24.05 189.22,26.55 189.06,26.71 188.85,26.71 v1(188.79,26.65)
  ART06 w0.108: v1(188.79,26.65) 189.82,25.61 189.82,25.12 190.17,24.77 194.06,24.77 195.48,26.19 195.48,29.4 198.73,32.66 199.46,32.66 201.42,34.61 201.89,34.61 203.3,36.02 203.3,37.41 204.19,38.3 204.19,42.6 197.66,49.13 197.66,50.5 197.13,51.03 197.13,53.78 196.2,54.7 v1(196.2,54.79)
M_A_A10: length 83.1
  TOP w0.135: v1(193.37,67.73) 193.23,67.73 192.95,68.01 U1.BJ38 ; v1(198.14,27.44) 198.14,28.95 196.29,30.8 196.29,33.75 196.56,34.01 196.86,34.01 197.06,33.81 197.06,33.47 197.47,33.06 CN11.146
  ART06 w0.108: v1(198.14,27.44) 198.14,26.8 198.48,26.46 198.48,23.96 197.52,23 197.52,21.93 197.13,21.55 187.3,21.55 185.83,23.02 185.83,32.12 185.94,32.23 186.21,32.23 186.31,32.33 186.31,32.55 186.21,32.66 185.94,32.66 185.83,32.77 185.83,32.98 185.94,33.09 186.21,33.09 186.31,33.2 186.31,33.41 186.21,33.52 185.94,33.52 185.83,33.63 185.83,33.84 185.94,33.95 186.21,33.95 186.31,34.06 186.31,34.28 186.21,34.38 185.94,34.38 185.83,34.49 185.83,34.71 185.94,34.82 186.21,34.82 186.31,34.92 186.31,35.14 186.21,35.25 185.94,35.25 185.83,35.36 185.83,35.57 185.94,35.68 186.21,35.68 186.31,35.79 186.31,36 186.21,36.11 185.94,36.11 185.83,36.22 185.83,36.6 192.05,42.83 192.05,50.75 192,50.8 192,57.93 192.68,58.61 192.68,58.93 192.57,59.04 192.09,59.04 191.99,59.15 191.99,59.37 192.09,59.47 192.57,59.47 192.68,59.58 192.68,59.8 192.57,59.91 192.09,59.91 191.99,60.01 191.99,60.23 192.09,60.34 192.57,60.34 192.68,60.44 192.68,62.13 193.63,63.09 193.63,64.54 193.96,64.86 193.96,65.39 193.75,65.6 193.75,67.36 v1(193.37,67.73)
M_A_A11: length 77.2
  TOP w0.076: v1(197.34,55.28) 197.06,55.28 196.89,55.46 196.89,57.55 196.34,58.1 196.34,61.12 196.33,61.12 196.33,61.18 196.33,61.18 196.33,62.05 196.33,62.05 196.33,62.08 196.17,62.25 196.17,62.44 196.2,62.61 196.2,62.78 196.18,62.86 196.18,63.19 U1.BB47
  TOP w0.135: v1(188.42,29.8) 188.81,29.8 188.97,29.97 CN11.120
  ART06 w0.108: v1(188.42,29.8) 188.17,29.56 188.17,27.27 188.07,27.16 188.07,25 189.08,23.99 194.68,23.99 196.41,25.72 196.41,29.15 199.24,31.98 200.59,31.98 206.45,37.84 206.45,39.19 207.82,40.56 207.82,43.5 207.7,43.62 207.48,43.62 207.39,43.52 207.39,40.74 207.28,40.64 207.07,40.64 206.95,40.75 206.95,43.51 205.98,44.49 205.98,44.64 206.13,44.79 206.29,44.79 207.1,43.98 207.23,43.98 207.38,44.14 207.38,44.31 206.52,45.18 202.96,45.18 198.64,49.49 198.64,50.58 197.76,51.46 197.76,55.08 197.56,55.28 v1(197.34,55.28)
M_A_A12: length 78.2
  TOP w0.075: U1.BE48 195.16,62.76
  TOP w0.076: v1(196.2,55.4) 195.93,55.13 195.63,55.13 195.49,55.27 195.49,55.4 195.57,55.48 195.72,55.48 195.8,55.55 195.8,55.71 195.72,55.78 195.57,55.78 195.49,55.86 195.49,56.01 195.57,56.09 195.72,56.09 195.8,56.16 195.8,56.32 195.72,56.39 195.57,56.39 195.49,56.47 195.49,60.87 194.9,61.46 194.9,62.48 194.92,62.52 195.16,62.76
  TOP w0.135: CN11.119 188.72,25.45 v1(188.76,25.49)
  ART06 w0.108: v1(196.2,55.4) 196.2,55.53 196.57,55.9 196.57,56.61 196.64,56.68 196.9,56.68 196.98,56.59 196.98,55.78 196.77,55.57 196.77,54.4 197.34,53.83 197.34,51.18 197.98,50.54 197.98,49.26 203.15,44.09 203.3,44.09 203.71,44.5 203.86,44.5 204.01,44.34 204.01,44.19 203.61,43.79 203.61,43.64 203.76,43.48 203.92,43.48 204.32,43.88 204.47,43.88 204.62,43.73 204.62,43.58 204.22,43.18 204.22,43.02 204.65,42.6 205.68,42.6 205.78,42.49 205.78,42.27 205.68,42.17 204.65,42.17 204.54,42.06 204.54,41.84 204.65,41.73 205.68,41.73 205.78,41.63 205.78,41.41 205.68,41.3 204.65,41.3 204.54,41.19 204.54,40.98 204.65,40.87 205.68,40.87 205.78,40.76 205.78,40.55 205.68,40.44 204.65,40.44 204.54,40.33 204.54,40.12 204.65,40.01 205.68,40.01 205.78,39.9 205.78,39.68 205.68,39.58 204.65,39.58 204.54,39.47 204.54,39.25 204.65,39.14 205.68,39.14 205.78,39.04 205.78,38.82 205.68,38.71 205.09,38.71 204.94,38.56 204.94,38.41 205.4,37.95 205.4,37.8 204.32,36.72 204.16,36.72 204.01,36.87 204.01,37.02 204.78,37.8 204.78,37.95 204.63,38.1 204.48,38.1 203.63,37.25 203.63,35.91 201.67,33.95 201.67,33.77 201.13,33.22 200.34,33.22 199.56,32.44 198.89,32.44 195.79,29.34 195.79,26.04 194.26,24.51 189.53,24.51 189.3,24.74 189.3,24.89 189.61,25.2 189.61,25.35 189.46,25.5 189.31,25.5 189,25.2 188.89,25.2 188.76,25.33 v1(188.76,25.49)
M_A_A13: length 83.3
  TOP w0.135: v1(192.45,67.1) 192.27,67.1 U1.BM39 ; CN11.158 200.47,31.03
  TOP w0.155: CN11.158 200.47,31.03 200.94,30.57 v1(200.94,29.81)
  ART06 w0.108: v1(192.45,67.1) 191.85,66.5 191.85,65.88 191,65.02 191,63.34 189.86,62.2 189.86,61.32 190.05,61.13 190.05,51.24 189.45,50.64 189.45,48.19 183.42,42.16 183.42,38.7 182.44,37.72 182.44,32.05 181.89,31.49 181.89,22.81 185.41,19.29 198.66,19.29 201.38,22.01 201.38,29.37 v1(200.94,29.81)
M_A_ACT_N: length 75.3
  TOP w0.076: v1(196.2,56.65) 195.66,57.19 195.66,60.94 195.07,61.52 195.07,62.3 U1.BE49
  TOP w0.135: CN11.114 187.47,30.46 v1(187.54,30.39)
  ART06 w0.108: v1(187.54,30.39) 187.61,30.32 187.9,30.32 188.06,30.16 188.06,29.96 187.86,29.76 187.86,27.42 187.69,27.25 187.69,24.92 188.87,23.73 194.89,23.73 196.72,25.56 196.72,29.07 199.4,31.76 200.81,31.76 206.77,37.72 206.77,38.94 207.51,39.68 207.66,39.68 207.81,39.53 207.81,39.37 207.19,38.74 207.19,38.6 207.34,38.45 207.5,38.45 208.68,39.63 208.68,40.86 208.57,40.97 208.3,40.97 208.2,41.07 208.2,41.29 208.3,41.4 208.57,41.4 208.68,41.5 208.68,41.72 208.57,41.83 208.3,41.83 208.2,41.94 208.2,42.15 208.3,42.26 208.57,42.26 208.68,42.37 208.68,42.58 208.57,42.69 208.3,42.69 208.2,42.8 208.2,43.02 208.3,43.12 208.57,43.12 208.68,43.23 208.68,43.45 208.57,43.56 208.3,43.56 208.2,43.66 208.2,44.12 206.78,45.54 203.04,45.54 198.95,49.62 198.95,50.55 198.77,50.73 198.75,50.73 197.95,51.54 197.95,56.55 197.61,56.88 197.57,56.88 197.57,56.89 196.44,56.89 v1(196.2,56.65)
M_A_BG0: length 75.4
  TOP w0.076: v1(197.35,55.91) 197.05,56.21 197.05,57.62 196.5,58.17 196.5,61.19 196.5,61.19 196.5,61.25 196.5,61.25 196.5,62.12 196.49,62.12 196.49,62.15 196.49,62.16 196.49,62.18 196.42,62.25 U1.BB49
  TOP w0.135: CN11.115 187.72,25.74
  TOP w0.155: v1(188.73,26.06) 188.38,26.06 188.1,26.35 188.1,26.57 188.39,26.86 188.39,27.08 188.17,27.3 187.95,27.3 187.66,27 187.44,27 185.92,28.53 185.62,28.53 185.42,28.32 185.42,28.04 187.72,25.74
  ART06 w0.108: v1(197.35,55.91) 197.35,55.88 196.97,55.5 196.97,54.5 197.55,53.91 197.55,51.35 198.3,50.61 198.3,49.4 202.84,44.86 205.17,44.86 206.62,43.4 206.62,43.23 206.47,43.08 206.34,43.08 204.94,44.47 204.8,44.47 204.64,44.32 204.64,44.16 205.12,43.69 205.12,43.53 204.82,43.24 204.82,43.09 204.97,42.93 205.13,42.93 205.42,43.23 205.57,43.23 206.49,42.32 206.49,42.14 206.38,42.04 206.23,42.04 206.12,41.93 206.12,41.71 206.23,41.61 206.38,41.61 206.49,41.5 206.49,41.28 206.38,41.17 206.23,41.17 206.12,41.07 206.12,40.85 206.23,40.74 206.38,40.74 206.49,40.63 206.49,40.42 206.38,40.31 206.23,40.31 206.12,40.2 206.12,37.96 201.01,32.84 200.86,32.84 200.7,33 200.55,33 200.4,32.84 200.4,32.69 200.55,32.54 200.55,32.39 200.38,32.22 199.04,32.22 196.1,29.27 196.1,25.85 194.5,24.25 189.38,24.25 188.38,25.25 188.38,25.95 188.49,26.06 v1(188.73,26.06)
M_A_BG1: length 76
  TOP w0.076: U1.BD47 195.64,63.05 195.64,62.97 195.57,62.9 195.57,62.86 195.55,62.83 195.55,62.57 195.56,62.56 195.56,62.4 195.56,62.12 195.43,61.99 195.43,61.64 196.01,61.07 196.01,57.96 196.56,57.42 196.56,53.92 196.88,53.6
  TOP w0.135: v1(196.2,53.57) 196.95,52.82 196.95,50.19 197.17,49.97 197.46,49.97 197.64,50.15 197.64,50.49 197.77,50.63 198.04,50.63 198.18,50.49 198.18,50.03 198.3,49.91 198.57,49.91 198.72,50.05 198.72,51.11 198.15,51.68 198.15,52.33 196.88,53.6
  TOP w0.155: CN11.113 187.22,24.05 187.22,25.64 184.87,27.99 184.47,27.99 184.36,28.09 184.36,28.38 184.87,28.89 186.06,28.89 187.11,27.84 188.58,27.84 188.79,27.63 v1(188.79,27.27)
  ART06 w0.108: v1(196.2,53.57) 196.62,53.57 196.87,53.32 196.87,51 196.93,50.92 197.12,50.73 197.16,50.73 197.35,50.55 197.35,48.99 203.87,42.47 203.87,38.47 202.94,37.54 202.94,36.1 201.71,34.87 201.36,34.87 199.38,32.9 198.6,32.9 195.17,29.47 195.17,26.32 193.88,25.04 190.35,25.04 190.15,25.23 190.15,25.99 188.87,27.27 v1(188.79,27.27)
M_A_BS0: length 80.5
  TOP w0.135: U1.BM43 192.24,65.41 v1(192.45,65.19) ; CN11.150 198.47,30 198.7,29.77 198.7,28.09 v1(199.07,27.72)
  ART06 w0.108: v1(192.45,65.19) 192.26,65.19 191.64,64.57 191.64,62.85 191.37,62.58 191.37,61.8 190.76,61.19 190.76,51.04 190.39,50.67 190.39,47.55 185.66,42.82 185.66,42.42 185.83,42.25 185.99,42.25 186.75,43.01 186.87,43.01 187.03,42.86 187.03,42.68 185.19,40.84 185.19,38.59 183.52,36.92 183.52,32.13 184.38,31.27 184.38,28.9 182.84,27.36 182.84,23.07 185.8,20.11 198.24,20.11 199.98,21.85 199.98,26.96 199.22,27.72 v1(199.07,27.72)
M_A_BS1: length 83.1
  TOP w0.135: U1.BG39 194.05,67.36 v1(194.31,67.1) ; CN11.145 197.22,23.19 196.86,22.83 194.7,22.83 194.55,22.68 194.55,22.18 194.72,22.01 195.56,22.01 196,21.56 196,21.29 195.87,21.17 195.62,21.17 195.48,21.03 195.48,20.76 195.62,20.63 195.86,20.63 196,20.48 196,20.21 195.87,20.09 195.62,20.09 195.48,19.95 195.48,19.63 195.63,19.49 196.74,19.49 197.09,19.84 197.09,22.07 v1(196.87,22.29)
  ART06 w0.108: v1(194.31,67.1) 193.94,66.73 193.94,65.67 194.14,65.47 194.14,64.79 194.14,64.78 194.14,64.68 193.86,64.4 193.86,62.91 192.91,61.96 192.91,58.47 192.19,57.75 192.19,50.88 192.36,50.7 192.36,42.7 186.64,36.98 186.64,35.39 186.75,35.28 187.39,35.28 187.5,35.18 187.5,31.95 187.39,31.84 187.18,31.84 187.07,31.95 187.07,34.74 186.96,34.85 186.75,34.85 186.64,34.74 186.64,31.85 186.13,31.34 186.13,24.13 186.35,23.91 186.35,23.76 186.1,23.51 186.1,23.36 186.25,23.21 186.4,23.21 186.65,23.45 186.8,23.45 187.18,23.08 187.18,22.36 187.71,21.83 195.02,21.83 195.13,21.94 195.13,22.26 195.23,22.37 195.45,22.37 195.56,22.26 195.56,21.94 195.67,21.83 195.88,21.83 195.99,21.94 195.99,22.26 196.1,22.37 196.31,22.37 196.42,22.26 196.42,21.94 196.53,21.83 196.84,21.83 196.98,21.97 196.98,22.19 v1(196.87,22.29)
M_A_CAS_N: length 80.4
  TOP w0.135: CN11.156 199.97,30.46 200.15,30.28 v1(200.44,30.28) ; U1.BJ42 193.14,66.06 v1(193.37,65.83)
  ART06 w0.108: v1(193.37,65.83) 193.37,65.71 193.76,65.32 193.76,64.93 193.38,64.55 193.38,63.13 192.44,62.19 192.44,61.67 191.73,60.96 191.73,43 184.94,36.21 184.94,33.25 185.54,32.65 185.54,22.87 186.34,22.07 186.34,21.91 186.11,21.68 186.11,21.52 186.26,21.37 186.41,21.37 186.65,21.61 186.8,21.61 187.15,21.26 197.19,21.26 197.89,21.96 197.89,22.85 198.27,23.23 198.42,23.23 199.04,22.61 199.19,22.61 199.34,22.77 199.34,23.02 198.81,23.56 198.81,24.29 198.92,24.4 199.29,24.4 199.4,24.51 199.4,24.72 199.29,24.83 198.92,24.83 198.81,24.94 198.81,26.53 198.92,26.63 199.45,26.63 199.55,26.74 199.55,26.96 199.45,27.07 198.74,27.07 198.63,27.18 198.63,27.49 198.24,27.88 198.24,28.08 198.52,28.36 198.67,28.36 198.88,28.14 199.04,28.14 199.19,28.3 199.19,28.45 198.97,28.66 198.97,28.82 199.13,28.97 199.28,28.97 199.49,28.76 199.65,28.76 199.8,28.91 199.8,29.06 199.59,29.27 199.59,29.43 199.74,29.58 199.89,29.58 200.1,29.37 200.26,29.37 200.41,29.52 200.41,29.67 200.2,29.89 200.2,30.04 v1(200.44,30.28)
M_A_CB0: length 3.8
  TOP w0.135: CN11.92 181.97,30.62 182.44,30.15 182.44,30.14 182.79,29.8 v1(182.98,29.8)
  BOTTOM w0.109: v1(182.98,29.8) 182.65,30.13 R739.2
M_A_CB1: length 2.9
  TOP w0.135: CN11.91 181.72,24.05 181.72,25.47 v1(181.22,25.97)
  BOTTOM w0.102: R741.2 181.85,25.74 181.45,25.74 v1(181.22,25.97)
M_A_CB2: length 2.1
  TOP w0.135: v1(184.19,25.38) 184.19,25.36 184.22,25.33 184.22,24.05 CN11.101
  BOTTOM w0.109: v1(184.19,25.38) 184.25,25.44 R742.2
M_A_CB3: length 3.7
  TOP w0.135: CN11.105 185.22,24.05 185.22,25.52 v1(184.19,26.55)
  BOTTOM w0.109: v1(184.19,26.55) 184.31,26.43 R743.2
M_A_CB4: length 2.8
  TOP w0.135: CN11.88 180.97,30.79 181.38,30.38 v1(181.48,30.38)
  BOTTOM w0.109: v1(181.48,30.38) 181.43,30.33 R744.2
M_A_CB5: length 2.8
  TOP w0.135: v1(180.22,25.97) 180.72,25.47 180.72,24.05 CN11.87
  BOTTOM w0.109: R745.2 180.28,26.02 v1(180.22,25.97)
M_A_CB6: length 1.9
  TOP w0.135: v1(183.98,30.97) 183.97,30.97 CN11.100
  BOTTOM w0.109: R746.2 184.6,30.97 v1(183.98,30.97)
M_A_CB7: length 3.4
  TOP w0.135: CN11.104 184.97,30.79 v1(183.98,29.8)
  BOTTOM w0.109: R748.2 184.46,29.8 v1(183.98,29.8)
M_A_CKE<0>: length 77.6
  TOP w0.076: v1(194.86,55.05) 194.47,55.44 194.47,56.38 194.29,56.56 194.29,56.62 194.29,56.62 194.29,58 193.86,58.43 193.86,58.57 193.86,58.57 193.86,61.12 193.86,61.12 193.86,61.26 193.98,61.38 193.98,61.51 194,61.53 194,62.1 193.98,62.12 193.98,62.32 U1.BG49
  TOP w0.155: v1(190.4,27.89) 190.33,27.89 190.18,28.05 190.18,28.52 190.04,28.67 189.73,28.67 189.56,28.5 189.56,28.05 189.41,27.89 189.1,27.89 188.94,28.05 188.94,28.96 188.77,29.13 188.46,29.13 188.32,28.99 188.32,28.46 188.07,28.21 187.27,28.21 186.22,29.27 184.72,29.27 184.17,28.72 182.16,28.72 181.43,27.98 180.55,27.98 180.42,28.12 180.42,28.43 180.59,28.6 180.94,28.6 181.14,28.81 181.14,29.14 181.01,29.27 179.74,29.27 179.39,28.92 179.39,28.27 180.53,27.12 181.95,27.12 182.41,27.58 182.41,28.05 182.57,28.21 182.88,28.21 183.03,28.06 183.03,27.27 183.19,27.12 183.49,27.12 183.99,27.62 184.69,27.62 186.22,26.09 186.22,24.05 CN11.109
  ART06 w0.108: v1(194.86,55.05) 195.27,55.05 195.41,54.9 195.41,51.24 196.1,50.55 196.1,48.42 200.7,43.83 200.7,38.43 200.37,38.1 199.55,38.1 199.11,37.66 199.11,37.37 198.15,36.41 198.15,35.78 196.55,34.18 196.55,33.33 195.01,31.79 194.16,31.79 193.78,31.42 193.78,30.62 193.87,30.53 193.87,26.89 193.06,26.08 191.45,26.08 190.16,27.37 190.16,27.65 v1(190.4,27.89)
M_A_CKE<1>: length 82.5
  TOP w0.135: CN11.110 186.47,31.17 186.34,31.03 185.74,31.03 184.7,30 184.7,29.77 184.83,29.65 185.18,29.65 185.18,29.65 185.24,29.65 185.38,29.78 185.38,29.95 185.51,30.09 185.78,30.09 185.92,29.95 185.92,29.78 186.05,29.65 186.32,29.65 186.46,29.78 186.46,30.4 186.6,30.54 186.87,30.54 187,30.41 187,29.32 187.14,29.18 187.32,29.18 187.46,29.32 v1(187.46,29.65) ; U1.BF41 194.99,66.71 v1(195.23,66.46)
  ART06 w0.108: v1(195.23,66.46) 195.37,66.46 195.69,66.15 195.69,65.75 195.97,65.46 195.98,65.46 196.01,65.42 196.01,63.34 196.22,63.13 196.22,60.5 198.77,57.95 198.77,51.85 199.95,50.66 200.12,50.66 200.3,50.49 200.3,50.04 203.43,46.91 207.31,46.91 210.02,44.2 210.02,39.14 202.17,31.29 201.81,31.29 201.23,30.71 200.33,30.71 197.34,27.72 197.34,25.28 195.26,23.2 188.47,23.2 187.06,24.6 187.06,29.25 v1(187.46,29.65)
M_A_CLK_DDR_DN#<0>: length 81
  TOP w0.075: U1.BL48 192.65,63.11 192.56,63.2 192.52,63.2 192.42,63.09 192.42,62.05 192.43,62.04
  TOP w0.109: CN11.139 193.72,25.03 193.56,25.19 193.56,27.92 193.67,28.03 193.89,28.03 194,27.92 194,25.61 194.23,25.37 194.63,25.37 194.87,25.61 194.87,27.92 194.98,28.03 195.2,28.03 195.31,27.92 195.31,25.61 195.55,25.37 195.95,25.37 196.19,25.61 196.19,28.67 195.8,29.06 194.13,29.06 193.87,29.32 193.87,29.79 193.63,30.02 193.23,30.02 192.99,29.79 192.99,29.21 192.84,29.06 192.42,29.06 v1(192.16,29.32) ; 192.43,62.04 192.43,61.54 192.79,61.18 192.79,58.24 192.27,57.72 192.27,56.83 192.05,56.61 191.51,56.61 191.3,56.4 191.3,54.12 191.41,54.01 192.06,54.01 192.28,53.8 192.28,53.42 192.06,53.21 190.39,53.21 190.28,53.1 190.28,52.88 190.39,52.77 192.06,52.77 192.28,52.55 192.28,52.18 192.06,51.96 190.11,51.96 189.98,51.83 189.98,51.37 190.11,51.24 192.64,51.24 192.77,51.37 192.77,53.19 193.08,53.5 193.47,53.5 193.6,53.63 v1(193.6,53.75)
  ART06 w0.087: v1(192.16,29.32) 192.16,29.23 192.01,29.09 191.45,29.09 191.06,29.48 191.06,30.81 189.85,32.02 189.85,32.6 190.1,32.85 190.5,32.85 190.58,32.76 190.58,32.29 190.79,32.09 191.11,32.09 191.3,32.27 191.3,32.76 191.38,32.85 192.6,32.85 193.71,33.96 193.71,34.3 193.52,34.49 193.25,34.49 193.17,34.58 193.17,34.75 193.25,34.84 193.52,34.84 193.71,35.03 193.71,35.36 193.52,35.55 193.25,35.55 193.17,35.64 193.17,35.81 193.25,35.9 193.52,35.9 193.71,36.09 193.71,36.42 194.46,37.16 194.46,50.44 194.44,50.46 194.44,50.65 194.07,51.01 194.07,53.26 193.6,53.74 v1(193.6,53.75)
M_A_CLK_DDR_DN#<1>: length 82.8
  TOP w0.109: U1.BF42 195.22,65.82 v1(195.23,65.83) ; CN11.140 193.97,33.23 193.84,33.37 193.84,33.82 194.55,34.53 194.55,38.28 194.12,38.71 192.37,38.71 192.08,38.42 192.08,37.06 192.32,36.83 192.72,36.83 192.95,37.06 192.95,37.73 193.06,37.83 193.28,37.83 193.39,37.73 193.39,35.72 193.19,35.52 v1(192.45,35.52)
  ART06 w0.075: v1(195.23,65.83) 195.23,65.74 195.34,65.63
  ART06 w0.087: v1(192.45,35.52) 192.43,35.52 192.22,35.3 190.76,35.3 190.12,35.95 190.12,36.07 190.24,36.19 190.36,36.19 190.66,35.9 190.93,35.9 191.16,36.13 191.16,36.4 190.44,37.12 190.16,37.12 189.61,36.57 189.49,36.57 189.33,36.73 189.33,37.37 192.59,40.62 192.71,40.62 192.83,40.5 192.83,40.38 190.39,37.94 190.39,37.67 190.62,37.44 190.9,37.44 192.64,39.17 192.76,39.17 192.88,39.05 192.88,38.93 191.28,37.33 191.28,37.05 191.51,36.82 191.78,36.82 192.65,37.68 192.77,37.68 192.89,37.56 192.89,37.44 192.59,37.13 192.59,36.86 192.82,36.63 193.09,36.63 193.83,37.36 193.83,37.64 193.27,38.19 193.27,38.31 193.82,38.85 193.82,39.13 193.26,39.68 193.26,39.8 193.76,40.3 193.76,40.58 193.21,41.13 193.21,41.25 193.88,41.92 193.88,50.59 193.17,51.3 193.17,57.14 193.41,57.38 193.84,57.38 194.02,57.56 194.02,58.06 194.11,58.14 194.28,58.14 194.37,58.06 194.37,57.56 194.55,57.38 194.85,57.38 195.11,57.64 195.49,57.64 195.67,57.82 195.67,58.19 195.75,58.28 195.93,58.28 196.01,58.19 196.01,57.82 196.2,57.64 196.65,57.64 196.99,57.98 196.99,58.88 196.73,59.14 195.45,59.14 195.34,59.25 195.34,59.5 195.43,59.59 195.92,59.59 196.1,59.77 196.1,60.08 195.92,60.26 195.43,60.26 195.34,60.35 195.34,60.52 195.43,60.61 195.79,60.61 195.97,60.79 195.97,61.1 195.79,61.28 195.43,61.28 195.34,61.37 195.34,61.85 195.79,62.29 195.79,65.31 195.47,65.63 195.34,65.63
M_A_CLK_DDR_DP<0>: length 81
  TOP w0.075: 192.24,62.04 192.24,62.04 192.26,62.06 192.26,62.11 192.26,62.11 192.26,63.15 192.65,63.54 U1.BL47
  TOP w0.109: 192.24,62.04 192.24,61.46 192.6,61.1 192.6,58.32 192.08,57.8 192.08,56.91 191.97,56.79 191.43,56.79 191.11,56.47 191.11,54.05 191.33,53.83 191.98,53.83 192.09,53.72 192.09,53.5 191.98,53.39 190.32,53.39 190.1,53.17 190.1,52.8 190.32,52.58 191.98,52.58 192.09,52.47 192.09,52.25 191.98,52.14 190.03,52.14 189.8,51.91 189.8,51.29 190.03,51.05 192.72,51.05 192.96,51.3 192.96,53.12 193.15,53.31 193.38,53.31 v1(193.59,53.11) ; CN11.137 193.22,24.97 193.35,25.1 193.34,25.1 193.34,28.01 193.58,28.25 193.98,28.25 194.22,28.01 194.22,25.7 194.32,25.59 194.54,25.59 194.65,25.7 194.65,28.01 194.89,28.25 195.29,28.25 195.53,28.01 195.53,25.7 195.64,25.59 195.86,25.59 195.97,25.7 195.97,28.58 195.71,28.84 194.04,28.84 193.65,29.23 193.65,29.7 193.54,29.81 193.32,29.81 193.21,29.7 193.21,29.11 192.94,28.84 192.42,28.84 v1(192.16,28.58)
  ART06 w0.087: v1(192.16,28.58) 192.16,28.81 192.06,28.9 191.37,28.9 190.87,29.4 190.87,30.74 189.67,31.94 189.67,32.68 190.02,33.03 190.57,33.03 190.77,32.84 190.77,32.36 190.86,32.27 191.03,32.27 191.11,32.35 191.11,32.84 191.31,33.03 192.53,33.03 193.53,34.04 193.53,34.22 193.44,34.31 193.18,34.31 192.98,34.5 192.98,34.83 193.18,35.02 193.44,35.02 193.53,35.11 193.53,35.28 193.44,35.37 193.18,35.37 192.98,35.56 192.98,35.89 193.18,36.08 193.44,36.08 193.53,36.17 193.53,36.5 194.27,37.24 194.27,50.58 193.91,50.95 193.91,52.94 193.75,53.11 v1(193.59,53.11)
M_A_CLK_DDR_DP<1>: length 82.8
  TOP w0.109: CN11.138 193.47,33.23 193.62,33.37 193.62,33.91 194.33,34.62 194.33,38.19 194.03,38.49 192.46,38.49 192.3,38.33 192.3,37.15 192.41,37.04 192.63,37.04 192.74,37.15 192.74,37.82 192.97,38.05 193.37,38.05 193.61,37.82 193.61,35.63 193.28,35.3 192.97,35.3 v1(192.45,34.78) ; v1(195.23,65.19) 195.22,65.19 U1.BF43
  ART06 w0.075: v1(195.23,65.19) 195.23,65.35 195.34,65.46
  ART06 w0.087: 195.34,65.46 195.4,65.46 195.62,65.24 195.62,62.36 195.18,61.92 195.18,61.3 195.36,61.12 195.73,61.12 195.81,61.03 195.81,60.86 195.73,60.77 195.36,60.77 195.18,60.59 195.18,60.28 195.36,60.1 195.85,60.1 195.94,60.01 195.94,59.84 195.85,59.75 195.36,59.75 195.18,59.57 195.18,59.18 195.39,58.98 196.66,58.98 196.82,58.81 196.82,58.05 196.58,57.8 196.26,57.8 196.18,57.89 196.18,58.26 195.99,58.44 195.69,58.44 195.5,58.26 195.5,57.89 195.42,57.8 195.04,57.8 194.79,57.55 194.62,57.55 194.53,57.63 194.53,58.13 194.35,58.31 194.04,58.31 193.86,58.13 193.86,57.63 193.78,57.55 193.34,57.55 193,57.21 193,51.23 193.7,50.54 193.7,42 193.03,41.33 193.03,41.05 193.58,40.5 193.58,40.38 193.08,39.88 193.08,39.6 193.63,39.05 193.63,38.93 193.09,38.39 193.09,38.11 193.64,37.56 193.64,37.44 193.02,36.81 192.89,36.81 192.77,36.93 192.77,37.06 193.08,37.36 193.08,37.64 192.85,37.87 192.57,37.87 191.71,37.01 191.59,37.01 191.46,37.13 191.46,37.25 193.07,38.85 193.07,39.13 192.84,39.36 192.56,39.36 190.82,37.62 190.7,37.62 190.58,37.74 190.58,37.86 193.01,40.3 193.01,40.58 192.78,40.81 192.51,40.81 189.15,37.44 189.15,36.66 189.41,36.39 189.69,36.39 190.24,36.94 190.36,36.94 190.98,36.32 190.98,36.2 190.86,36.08 190.73,36.08 190.44,36.37 190.16,36.37 189.93,36.14 189.93,35.87 190.68,35.12 192.11,35.12 v1(192.45,34.78)
M_A_CS#<0>: length 81.6
  TOP w0.135: v1(199.26,25.98) 198.57,25.98 198.22,25.63 198.22,24.05 CN11.149 ; U1.BM38 192.05,68.01 192.32,67.73 v1(192.46,67.73)
  ART06 w0.108: v1(199.26,25.98) 199.51,25.98 199.7,25.79 199.7,22.08 198.01,20.39 185.92,20.39 183.11,23.21 183.11,24.73 183.67,25.28 183.67,27.4 184.67,28.4 184.67,31.47 183.85,32.28 183.85,36.7 185.52,38.37 185.52,40.73 187.51,42.71 187.51,44.18 189.35,46.02 189.51,46.02 189.66,45.87 189.66,45.72 187.95,44.01 187.95,43.83 188.09,43.7 188.25,43.7 190.76,46.21 190.76,50.72 191.01,50.98 191.01,61.16 191.62,61.78 191.62,62.5 192.47,63.35 192.47,64.65 192.82,65 192.82,67.38 v1(192.46,67.73)
M_A_CS#<1>: length 81.7
  TOP w0.135: CN11.157 200.22,26.65 199.88,27 197.95,27 197.63,27.32 197.63,28.16 197.49,28.3 196.82,28.3 196.63,28.12 196.63,25.78 196.9,25.51 197.23,25.51 197.76,26.04 v1(197.76,26.34) ; U1.BG42 194.08,66.06 v1(194.31,65.83)
  ART06 w0.108: v1(197.76,26.34) 197.83,26.34 198.13,26.04 198.13,24.38 197.89,24.14 197.35,24.14 197.17,23.96 197.17,23.4 196.93,23.17 196.19,23.17 195.67,22.65 194.98,22.65 194.88,22.54 194.88,22.29 194.77,22.18 194.55,22.18 194.44,22.29 194.44,22.54 194.34,22.65 194.12,22.65 194.01,22.54 194.01,22.29 193.9,22.18 193.69,22.18 193.58,22.29 193.58,22.54 193.47,22.65 193.26,22.65 193.15,22.54 193.15,22.29 193.04,22.18 192.82,22.18 192.72,22.29 192.72,22.54 192.61,22.65 192.1,22.65 191.57,22.12 187.9,22.12 187.57,22.44 187.57,23.14 186.44,24.27 186.44,31.08 186.72,31.36 187.66,31.36 187.95,31.65 187.95,35.53 187.84,35.64 187.08,35.64 186.97,35.74 186.97,35.96 187.08,36.07 187.84,36.07 187.95,36.18 187.95,36.39 187.84,36.5 187.15,36.5 187.04,36.61 187.04,36.94 192.67,42.57 192.67,50.66 192.37,50.97 192.37,57.67 193.81,59.11 193.81,59.65 193.7,59.76 193.3,59.76 193.2,59.87 193.2,60.09 193.3,60.19 193.7,60.19 193.81,60.3 193.81,60.52 193.7,60.63 193.3,60.63 193.2,60.73 193.2,60.95 193.3,61.06 193.7,61.06 193.81,61.17 193.81,61.99 194.15,62.33 194.15,62.8 194.25,62.91 194.51,62.91 194.61,63.01 194.61,63.23 194.51,63.34 194.25,63.34 194.15,63.45 194.15,64.26 194.34,64.45 194.34,65.8 v1(194.31,65.83)
M_A_DQ<0>: length 48.7
  TOP w0.076: 184.61,55.8 184.61,56.59 186.12,58.1 186.81,58.1 186.81,58.1 187.21,58.1 187.75,58.64 187.75,61.05 187.3,61.49 187.3,62.31 U1.CA48
  TOP w0.087: 184.61,55.8 184.11,55.29 v1(183.87,55.29)
  TOP w0.109: v1(170.72,25.95) 170.22,25.45 170.22,24.05 CN11.45
  ART06 w0.087: v1(183.87,55.29) 183.01,54.43 183.01,53.24 182.45,52.67 182.45,51.11 170.38,39.05 170.38,36.54 171.08,35.85 171.08,31.98 170.6,31.5 170.6,28.74 169.9,28.05 169.9,26.41 170.37,25.95 v1(170.72,25.95)
M_A_DQ<1>: length 49.3
  TOP w0.076: 184.59,53.53 185.15,54.09 185.15,56.62 186.26,57.72 186.9,57.72 186.92,57.74 187.32,57.74 188.1,58.53 188.1,61.16 187.72,61.54 187.72,61.56 187.72,61.56 187.72,62.07 187.89,62.23 187.89,62.5 187.87,62.51 187.87,62.54 187.87,62.54 187.87,62.81 187.88,62.87 187.89,62.92 187.89,63.19 187.65,63.42 U1.CA47
  TOP w0.109: v1(170.72,26.58) 171.22,26.08 171.22,24.05 CN11.49 ; v1(183.9,53.4) 184.46,53.4 184.59,53.53
  ART06 w0.087: v1(170.72,26.58) 170.49,26.58 170.19,26.89 170.19,27.9 170.3,28.01 170.42,28.01 170.51,27.93 170.63,27.93 170.75,28.05 170.75,28.18 170.67,28.26 170.67,28.38 171.66,29.37 171.66,39.5 183.07,50.92 183.07,52.34 183.9,53.17 v1(183.9,53.4)
M_A_DQ<2>: length 47.6
  TOP w0.076: v1(183.87,53.98) 184.29,53.98 184.99,54.68 184.99,56.68 186.19,57.88 186.83,57.88 186.85,57.91 186.85,57.91 186.88,57.94 187.28,57.94 187.94,58.6 187.94,61.09 187.56,61.47 187.56,61.49 187.55,61.49 187.55,62.13 187.56,62.14 187.56,62.29 U1.CA49
  TOP w0.109: CN11.50 171.47,30.79 171.06,30.37 v1(171,30.37)
  ART06 w0.087: v1(183.87,53.98) 183.78,53.98 183.36,53.56 183.36,53.05 182.78,52.47 182.78,51.03 170.67,38.93 170.67,36.66 170.77,36.57 170.94,36.57 171.02,36.65 171.02,38.72 171.11,38.81 171.28,38.81 171.37,38.72 171.37,30.56 171.19,30.38 171.01,30.38 v1(171,30.37)
M_A_DQ<3>: length 48.4
  TOP w0.076: v1(186.12,54.33) 186.44,54.33 187.3,55.2 187.3,56.66 187.61,56.96 187.61,56.96 187.68,57.04 187.68,57.04 187.76,57.12 187.76,57.12 188.71,58.08 188.72,58.08 188.92,58.28 188.92,61.25 188.99,61.32 188.99,62.31 U1.BV49
  TOP w0.109: v1(173.77,25.37) 173.77,24.1 CN11.59
  ART06 w0.087: v1(173.77,25.37) 173.21,25.92 173.21,27.94 173.67,28.39 173.67,32.18 173.44,32.41 173.28,32.41 173.19,32.49 173.19,32.67 173.28,32.75 173.58,32.75 173.67,32.84 173.67,33.01 173.58,33.1 173.28,33.1 173.19,33.19 173.19,33.36 173.28,33.44 173.58,33.44 173.67,33.53 173.67,33.7 173.58,33.79 173.28,33.79 173.19,33.88 173.19,34.05 173.28,34.14 173.58,34.14 173.67,34.22 173.67,34.4 173.58,34.48 173.28,34.48 173.19,34.57 173.19,34.74 173.28,34.83 173.58,34.83 173.67,34.92 173.67,39.56 184.69,50.58 184.69,51.99 185.34,52.65 185.34,53.73 185.95,54.33 v1(186.12,54.33)
M_A_DQ<4>: length 50.3
  TOP w0.076: 184.11,56.32 186.05,58.26 186.74,58.26 186.74,58.27 187,58.27 187.56,58.82 187.56,60.98 187.11,61.43 187.11,62.3 187.31,62.71 187.33,62.81 187.33,63.8 187.65,64.12 U1.CA45
  TOP w0.087: 184.11,56.32 184.11,56.22 v1(183.87,55.99)
  TOP w0.109: v1(169.88,30.38) 170.03,30.38 170.47,30.83 CN11.46
  ART06 w0.087: v1(183.87,55.99) 183.78,55.89 183.72,55.89 182.69,54.86 182.69,53.43 182.11,52.85 182.11,51.19 170.09,39.17 170.09,33.28 170.19,33.19 170.36,33.19 170.44,33.27 170.44,35.65 170.54,35.75 170.71,35.75 170.79,35.67 170.79,32.1 170.3,31.61 170.3,30.8 v1(169.88,30.38)
M_A_DQ<5>: length 49.8
  TOP w0.076: 186.86,52.97 187.23,53.34 187.23,54.12 187.63,54.53 187.63,56.52 188.01,56.9 188.01,56.9 188.09,56.98 188.09,56.99 188.85,57.75 188.86,57.75 189.25,58.14 189.25,61.12 189.34,61.2 189.34,62.57 189.22,62.83 189.22,63.38 U1.BV47
  TOP w0.109: 186.86,52.97 186.46,52.57 v1(186.05,52.57) ; v1(174.47,30.91) 174.47,30.92 CN11.62
  ART06 w0.087: v1(174.47,30.91) 174.46,30.92 174.46,34.28 175.46,35.28 175.46,39.6 175.37,39.69 175.2,39.69 175.11,39.6 175.11,35.6 175.03,35.52 174.86,35.52 174.76,35.61 174.76,39.83 185.28,50.35 185.28,51.77 186.05,52.53 v1(186.05,52.57)
M_A_DQ<6>: length 50.4
  TOP w0.076: U1.BV45 188.18,64.33 187.99,64.15 187.99,63.37 188.03,63.28 188.05,63.25 188.05,63.2 188.06,63.09 188.06,62.97 188.05,62.92 188.05,62.8 188.04,62.78 188.04,62.6 188.05,62.51 188.05,62.17 187.88,62 187.88,61.63 188.33,61.18 188.33,58.52 187.36,57.55 186.32,57.55 185.53,56.76 185.53,55.45 185.99,54.98 v1(186.15,54.98)
  TOP w0.109: CN11.58 173.47,30.14 v1(172.98,29.64)
  ART06 w0.087: v1(172.98,29.64) 173.37,30.04 173.37,31.24 172.83,31.78 172.83,35.29 172.92,35.38 173.23,35.38 173.32,35.47 173.32,35.64 173.23,35.72 172.92,35.72 172.83,35.81 172.83,35.98 172.92,36.07 173.23,36.07 173.32,36.16 173.32,36.33 173.23,36.42 172.92,36.42 172.83,36.5 172.83,36.68 172.92,36.76 173.23,36.76 173.32,36.85 173.32,37.02 173.23,37.11 172.92,37.11 172.83,37.2 172.83,37.37 172.92,37.46 173.23,37.46 173.32,37.54 173.32,37.72 173.23,37.8 172.92,37.8 172.83,37.89 172.83,38.06 172.92,38.15 173.23,38.15 173.32,38.24 173.32,38.41 173.23,38.5 173,38.5 172.83,38.66 172.83,39.13 184.39,50.69 184.39,52.1 185.06,52.77 185.06,53.89 v1(186.15,54.98)
M_A_DQ<7>: length 49
  TOP w0.076: 186.56,53.27 186.9,53.61 186.9,54.1 187.47,54.66 187.47,56.59 187.77,56.89 187.77,56.9 187.84,56.97 187.84,56.97 187.92,57.05 187.92,57.05 188.78,57.91 188.79,57.91 189.09,58.21 189.09,61.19 189.15,61.25 189.15,62.51 U1.BV48
  TOP w0.109: 186.56,53.27 186.5,53.21 v1(186.08,53.21) ; CN11.63 174.72,24.05 174.72,25.69 173.88,26.54 v1(173.77,26.54)
  ART06 w0.087: v1(186.08,53.21) 185.86,53.21 185.63,52.98 185.63,52.53 184.98,51.88 184.98,50.46 184.98,50.46 174.07,39.55 174.07,39.04 174.15,38.96 174.37,38.96 174.45,38.87 174.45,38.7 174.37,38.61 174.15,38.61 174.07,38.52 174.07,38.35 174.15,38.26 174.37,38.26 174.45,38.18 174.45,38 174.37,37.92 174.15,37.92 174.07,37.83 174.07,37.66 174.15,37.57 174.37,37.57 174.45,37.48 174.45,37.31 174.37,37.22 174.15,37.22 174.07,37.14 174.07,36.96 174.15,36.88 174.37,36.88 174.45,36.79 174.45,36.62 174.37,36.53 174.15,36.53 174.07,36.45 174.07,36.27 174.15,36.19 174.27,36.19 174.42,36.04 174.42,35.74 174.07,35.39 174.07,28.26 174.27,28.07 174.27,27.04 v1(173.77,26.54)
M_A_DQ<8>: length 55.5
  TOP w0.109: U1.CC42 v1(187,65.81) ; v1(163.36,29.23) 163.36,28.47 163.03,28.14 162.32,28.14 161.94,28.51 161.94,28.9 162.91,29.87 162.91,31.25 162.97,31.31 CN11.16
  ART06 w0.087: v1(187,65.81) 187,65.69 187.47,65.23 187.47,63.98 187.05,63.56 186.24,63.56 182.9,60.22 181.85,60.22 177.3,55.67 177.3,55.29 176.67,54.66 176.67,52.64 162.77,38.74 162.77,29.82 v1(163.36,29.23)
M_A_DQ<9>: length 56.7
  TOP w0.109: CN11.20 163.97,30.9 163.47,30.4 v1(163.36,30.4) ; U1.CC39 186.81,67.19 186.9,67.14 v1(186.97,67.1)
  ART06 w0.087: v1(186.97,67.1) 187.36,66.71 187.36,65.59 187.64,65.31 187.64,63.91 187.12,63.39 186.31,63.39 182.97,60.05 181.95,60.05 177.59,55.69 177.59,55.14 176.99,54.54 176.99,52.39 163.06,38.46 163.06,35.85 163.75,35.16 163.75,32.55 163.67,32.47 163.5,32.47 163.41,32.56 163.41,34.81 163.32,34.9 163.15,34.9 163.06,34.81 163.06,30.7 v1(163.36,30.4)
M_A_DQ<10>: length 54.6
  TOP w0.109: U1.CC43 v1(187.02,65.17) ; CN11.17 163.22,24.05 163.22,25.43 v1(162.72,25.93)
  ART06 w0.087: v1(162.72,25.93) 163.12,26.32 163.12,27.44 163.04,27.52 162.74,27.52 162.66,27.61 162.66,27.78 162.74,27.87 163.04,27.87 163.13,27.95 163.13,28.13 163.04,28.21 162.74,28.21 162.66,28.3 162.66,28.47 162.74,28.56 163.04,28.56 163.13,28.65 163.13,28.86 162.48,29.51 162.48,38.91 176.21,52.64 176.21,54.63 176.98,55.4 176.98,55.65 181.72,60.39 182.81,60.39 187.02,64.6 v1(187.02,65.17)
M_A_DQ<11>: length 56.3
  TOP w0.109: v1(159.47,30.38) 159.56,30.38 159.97,30.79 CN11.4 ; U1.CE38 185.93,67.81 v1(186.06,67.73)
  ART06 w0.087: v1(186.06,67.73) 185.91,67.73 185.5,67.32 185.5,66.92 185.29,66.71 184.9,66.71 184.69,66.49 184.69,65.25 176.48,57.05 175.65,57.05 173.74,55.14 173.74,53.01 160.05,39.32 160.05,33.43 159.97,33.34 159.25,33.34 159.16,33.25 159.16,33.08 159.25,32.99 159.97,32.99 160.05,32.91 160.05,32.73 159.97,32.65 159.25,32.65 159.16,32.56 159.16,32.39 159.25,32.3 159.97,32.3 160.05,32.21 160.05,32.04 159.97,31.95 159.45,31.95 159.37,31.87 159.37,31.69 159.45,31.61 159.97,31.61 160.05,31.52 160.05,30.63 159.8,30.38 v1(159.47,30.38)
M_A_DQ<12>: length 57.8
  TOP w0.109: U1.CC38 186.82,67.83 v1(186.97,67.73) ; CN11.21 164.22,24.05 v1(164.22,25.34)
  ART06 w0.087: v1(164.22,25.34) 163.62,25.34 163.43,25.52 163.43,26.07 163.52,26.16 163.65,26.16 163.74,26.24 163.74,26.42 163.65,26.5 163.52,26.5 163.43,26.59 163.43,26.76 163.52,26.85 163.65,26.85 163.74,26.94 163.74,27.11 163.65,27.2 163.52,27.2 163.43,27.28 163.43,28.61 163.83,29.01 163.83,31.79 164.04,32.01 164.04,35.29 163.35,35.98 163.35,38.29 177.37,52.31 177.37,54.45 177.89,54.97 177.89,55.71 182.06,59.88 183.04,59.88 186.35,63.2 187.17,63.2 187.82,63.85 187.82,65.38 187.53,65.67 187.53,67.18 v1(186.97,67.73)
M_A_DQ<13>: length 55.9
  TOP w0.109: v1(186.06,67.1) 185.94,67.16 U1.CE39 ; v1(159.22,26.03) 159.72,25.53 159.72,24.05 CN11.3
  ART06 w0.087: v1(186.06,67.1) 185.57,66.61 185.57,65.47 184.6,64.51 184.25,64.51 179.97,60.23 179.9,60.23 176.44,56.77 175.84,56.77 174.06,54.99 174.06,52.92 160.34,39.2 160.34,26.51 159.87,26.03 v1(159.22,26.03)
M_A_DQ<14>: length 54.2
  TOP w0.109: CN11.7 160.72,24.05 160.72,27.36 v1(161.28,27.91) ; U1.CE42 185.83,66.06 185.95,65.93 v1(186.06,65.83)
  ART06 w0.087: v1(161.28,27.91) 160.65,28.54 160.65,39.1 174.38,52.83 174.38,54.87 175.94,56.43 176.34,56.43 179.92,60 180.1,60 183.38,63.28 184.32,63.28 185.64,64.6 185.64,65.3 186.06,65.72 v1(186.06,65.83)
M_A_DQ<15>: length 53.4
  TOP w0.109: v1(161.41,30.38) 160.97,30.81 CN11.8 ; U1.CE43 185.9,65.27 v1(186.06,65.19)
  ART06 w0.087: v1(186.06,65.19) 186.06,64.77 184.41,63.12 183.46,63.12 180.12,59.78 179.93,59.78 176.35,56.19 176.12,56.19 174.7,54.78 174.7,52.74 161.38,39.41 161.38,38.75 161.29,38.66 161.03,38.66 160.95,38.58 160.95,38.4 161.03,38.32 161.29,38.32 161.38,38.23 161.38,38.06 161.29,37.97 161.03,37.97 160.95,37.88 160.95,37.71 161.03,37.62 161.29,37.62 161.38,37.54 161.38,37.36 161.29,37.28 161.03,37.28 160.95,37.19 160.95,37.02 161.03,36.93 161.29,36.93 161.38,36.84 161.38,36.67 161.29,36.58 161.03,36.58 160.95,36.5 160.95,36.32 161.03,36.24 161.29,36.24 161.38,36.15 161.38,35.98 161.29,35.89 161.03,35.89 160.95,35.8 160.95,35.63 161.03,35.54 161.29,35.54 161.38,35.46 161.38,35.28 161.29,35.2 161.03,35.2 160.95,35.11 160.95,34.94 161.03,34.85 161.29,34.85 161.38,34.76 161.38,34.59 161.29,34.51 161.03,34.51 160.95,34.42 160.95,34.25 161.03,34.16 161.29,34.16 161.38,34.07 161.38,31.8 160.95,31.37 160.95,30.73 161.29,30.38 v1(161.41,30.38)
M_A_DQ<16>: length 46.5
  TOP w0.076: U1.BT48 189.9,62.48 189.9,61.42 190.29,61.02 190.29,60.6 190.29,60.6 190.29,59.71 190.29,59.57 190.29,59.57 190.29,59.2 190.4,59.09 190.4,58.3 189.52,57.42 188.99,57.42 188.42,56.85 188.42,55.53 v1(188.01,55.12)
  TOP w0.109: CN11.70 176.47,29.71 v1(175.97,29.21)
  ART06 w0.087: v1(188.01,55.12) 186.83,53.94 186.83,52.41 186.06,51.64 186.06,50.01 178.96,42.91 178.96,42.79 179.11,42.65 179.11,42.52 178.98,42.4 178.86,42.4 178.72,42.55 178.59,42.55 178.47,42.42 178.47,42.3 178.62,42.16 178.62,42.03 178.49,41.91 178.37,41.91 178.23,42.06 178.1,42.06 177.98,41.93 177.98,41.81 178.13,41.67 178.13,41.54 178,41.42 177.88,41.42 177.74,41.57 177.61,41.57 177.49,41.44 177.49,41.32 177.64,41.18 177.64,41.05 177.51,40.93 177.39,40.93 177.25,41.08 177.12,41.08 176.58,40.53 176.58,34.77 175.23,33.43 175.23,29.9 175.91,29.21 v1(175.97,29.21)
M_A_DQ<17>: length 46.8
  TOP w0.076: U1.BT47 189.85,63.38 189.85,62.98 189.75,62.89 189.76,62.88 189.76,62.59 189.73,62.56 189.73,61.35 189.73,61.31 190.13,60.91 190.13,60.53 190.13,60.53 190.13,58.52 189.19,57.58 188.92,57.58 188.25,56.92 188.25,56.91 188.18,56.83 188.18,56.53 v1(188.01,56.36)
  TOP w0.109: CN11.67 175.72,24.05 v1(175.72,25.38)
  ART06 w0.087: v1(188.01,56.36) 188.01,56.35 186.54,54.88 186.54,52.53 185.77,51.76 185.77,50.13 176.23,40.59 176.23,34.95 174.88,33.6 174.88,29.47 175.22,29.13 175.22,25.89 v1(175.72,25.38)
M_A_DQ<18>: length 45.5
  TOP w0.076: U1.BT49 190.06,62.3 190.06,61.48 190.46,61.09 190.46,60.67 190.46,60.67 190.46,59.78 190.46,59.26 190.57,59.15 190.57,59.02 190.57,58.24 189.58,57.25 189.05,57.25 188.58,56.78 188.58,55.46 188.58,55.45 188.58,55.08 v1(188.01,54.51)
  TOP w0.109: v1(175.97,30.38) 175.9,30.38 175.47,30.81 CN11.66
  ART06 w0.087: v1(188.01,54.51) 187.12,53.62 187.12,52.29 186.35,51.52 186.35,49.89 179.53,43.08 179.53,42.49 177.58,40.53 177.58,40.4 177.7,40.27 177.81,40.27 179.19,41.66 179.33,41.66 179.45,41.53 179.45,41.43 177.08,39.06 177.08,34.77 175.56,33.25 175.56,30.8 v1(175.97,30.38)
M_A_DQ<19>: length 45.7
  TOP w0.076: U1.BN49 191.46,62.34 191.46,62.19 191.46,62.19 191.46,62.15 191.47,62.14 191.47,61.87 191.47,61.87 191.47,61.68 191.47,61.68 191.47,61.41 191.34,61.28 191.34,59.93 191.34,59.66 191.42,59.57 191.42,57.58 191.41,57.57 190.18,56.33 190.18,55.8 189.72,55.35 189.72,54.44 v1(189.32,54.04)
  TOP w0.109: v1(179.21,25.99) 178.72,25.5 178.72,24.05 CN11.79
  ART06 w0.087: v1(189.32,54.04) 189.14,54.04 188.76,53.65 188.76,51.56 188.04,50.85 188.04,49.1 181.65,42.7 181.65,39.76 179.07,37.18 179.07,33.74 178.31,32.98 178.31,27.24 178.4,27.15 178.7,27.15 178.78,27.06 178.78,26.89 178.7,26.8 178.4,26.8 178.31,26.72 178.31,26.17 178.49,25.99 v1(179.21,25.99)
M_A_DQ<20>: length 47.8
  TOP w0.076: v1(189.32,55.87) 189.78,56.33 189.78,56.56 189.91,56.69 189.92,56.69 191.09,57.86 191.09,59.44 191.01,59.52 191.01,60.07 191.01,60.07 191.01,61.42 191.14,61.55 191.14,62.01 191,62.14 191,62.36 191.02,62.6 191.02,62.79 190.98,62.95 190.98,63.15 191.08,63.46 191.08,64.14 190.89,64.33 U1.BT45
  TOP w0.109: v1(176.99,28.61) 177,28.61 177.01,28.63 177.74,28.63 178.97,29.87 CN11.80
  ART06 w0.087: v1(189.32,55.87) 189.04,55.87 188.39,55.21 188.39,52.02 187.45,51.07 187.45,49.35 180.9,42.8 180.9,39.93 178.27,37.3 178.27,34.3 177.54,33.57 177.54,28.79 177.37,28.61 v1(176.99,28.61)
M_A_DQ<21>: length 47.4
  TOP w0.076: v1(189.32,55.26) 190,55.94 190,56.41 191.26,57.66 191.26,59.5 191.17,59.59 191.17,60 191.17,61.35 191.3,61.48 191.3,61.61 191.3,62.07 191.3,62.08 191.3,62.12 191.17,62.24 191.17,62.37 191.19,62.38 191.19,62.53 191.19,62.54 191.19,62.59 191.2,62.61 191.2,62.78 191.17,62.88 191.17,63.18 U1.BN47
  TOP w0.109: v1(177.78,26.56) 177.3,26.56 176.72,25.99 176.72,24.05 CN11.71
  ART06 w0.087: v1(189.32,55.26) 188.93,55.26 188.57,54.89 188.57,51.78 187.74,50.95 187.74,49.2 181.31,42.77 181.31,39.85 178.75,37.29 178.75,34.07 177.92,33.24 177.92,28.65 176.94,27.67 176.94,26.76 177.14,26.56 v1(177.78,26.56)
M_A_DQ<22>: length 47.6
  TOP w0.076: v1(189.32,52.17) 189.79,52.65 189.79,53.52 190.26,53.98 190.26,55.25 190.57,55.56 190.57,56.23 191.76,57.42 191.76,57.73 191.76,57.73 191.76,59 191.75,59 191.75,59.62 191.76,59.62 191.76,59.71 191.67,59.79 191.67,61.14 191.8,61.27 191.8,61.29 191.82,61.31 191.82,61.31 191.83,61.32 191.83,62.47 191.82,62.53 191.82,62.58 191.81,62.59 191.81,62.88 191.81,62.89 191.74,62.96 191.74,63.8 191.41,64.12 U1.BN45
  TOP w0.109: CN11.84 179.97,30.83 v1(179.49,30.35)
  ART06 w0.087: v1(179.49,30.35) 179.49,30.35 179.06,30.77 179.06,32.68 179.71,33.33 179.71,36.62 179.79,36.7 179.97,36.7 180.06,36.61 180.06,34 180.14,33.91 180.31,33.91 180.4,34 180.4,37.36 182.3,39.26 182.3,42.45 188.62,48.77 188.62,50.61 189.32,51.31 v1(189.32,52.17)
M_A_DQ<23>: length 46.4
  TOP w0.076: v1(189.32,53.43) 189.96,54.07 189.96,55.3 190.4,55.74 190.4,56.31 191.59,57.51 191.59,58.93 191.59,58.93 191.59,59.64 191.5,59.73 191.5,59.86 191.5,61.21 191.63,61.34 191.63,61.36 191.65,61.38 191.65,62.51 191.64,62.52 191.64,62.56 U1.BN48
  TOP w0.109: v1(179.21,27.22) 179.72,26.7 179.72,24.05 CN11.83
  ART06 w0.087: v1(179.21,27.22) 178.62,27.8 178.62,28.18 178.71,28.27 178.99,28.27 179.08,28.36 179.08,28.53 178.99,28.62 178.71,28.62 178.62,28.7 178.62,28.88 178.71,28.96 178.99,28.96 179.08,29.05 179.08,29.22 178.99,29.31 178.71,29.31 178.62,29.39 178.62,32.78 179.41,33.57 179.41,36.96 181.97,39.53 181.97,42.57 188.33,48.93 188.33,50.73 188.95,51.35 188.95,53.14 189.24,53.43 v1(189.32,53.43)
M_A_DQ<24>: length 56
  TOP w0.109: v1(189.73,65.78) 189.27,66.01 U1.BV42 ; v1(169.22,25.34) 169.22,24.05 CN11.41
  ART06 w0.087: v1(189.73,65.78) 189.73,65.7 190.1,65.33 190.1,63.8 188.66,62.36 188.66,61.29 185.03,57.66 183.98,57.66 181.04,54.73 181.04,51.75 167.81,38.52 167.81,34.22 167.63,34.03 167.47,34.03 167.39,33.95 167.39,33.77 167.47,33.69 167.72,33.69 167.81,33.6 167.81,33.43 167.72,33.34 167.47,33.34 167.39,33.25 167.39,33.08 167.47,32.99 167.72,32.99 167.81,32.91 167.81,32.73 167.72,32.65 167.47,32.65 167.39,32.56 167.39,32.39 167.47,32.3 167.72,32.3 167.81,32.21 167.81,32.04 167.72,31.95 167.47,31.95 167.39,31.87 167.39,31.69 167.47,31.61 167.72,31.61 167.81,31.52 167.81,31.35 167.72,31.26 167.47,31.26 167.39,31.17 167.39,31 167.47,30.91 167.64,30.91 167.81,30.74 167.81,28.98 168.68,28.11 168.68,25.89 v1(169.22,25.34)
M_A_DQ<25>: length 56.5
  TOP w0.109: v1(189.72,67.1) 189.59,67.17 U1.BV39 ; v1(168.97,30.38) 168.47,30.88 CN11.38
  ART06 w0.087: v1(189.72,67.1) 189.99,67.1 190.09,67 190.09,65.6 190.27,65.43 190.27,63.74 190.25,63.72 190.25,63.72 188.83,62.29 188.83,60.13 186.18,57.49 184.19,57.49 181.42,54.72 181.42,51.68 168.13,38.39 168.13,37.96 168.21,37.87 168.46,37.87 168.55,37.78 168.55,37.61 168.46,37.52 168.21,37.52 168.13,37.44 168.13,37.26 168.21,37.18 168.46,37.18 168.55,37.09 168.55,36.92 168.46,36.83 168.21,36.83 168.13,36.74 168.13,36.57 168.21,36.48 168.46,36.48 168.55,36.4 168.55,36.22 168.46,36.14 168.21,36.14 168.13,36.05 168.13,35.88 168.21,35.79 168.46,35.79 168.55,35.7 168.55,35.53 168.46,35.44 168.21,35.44 168.13,35.36 168.13,35.18 168.21,35.1 168.46,35.1 168.55,35.01 168.55,34.84 168.46,34.75 168.21,34.75 168.13,34.66 168.13,34.49 168.21,34.41 168.46,34.41 168.55,34.32 168.55,34.15 168.46,34.06 168.21,34.06 168.13,33.97 168.13,33.8 168.21,33.71 168.46,33.71 168.55,33.63 168.55,33.45 168.46,33.37 168.21,33.37 168.13,33.28 168.13,33.11 168.21,33.02 168.46,33.02 168.55,32.93 168.55,32.76 168.46,32.67 168.21,32.67 168.13,32.59 168.13,32.41 168.21,32.33 168.46,32.33 168.55,32.24 168.55,32.07 168.46,31.98 168.21,31.98 168.13,31.89 168.13,30.68 168.43,30.38 v1(168.97,30.38)
M_A_DQ<26>: length 55.1
  TOP w0.109: U1.BV43 189.27,65.39 v1(189.74,65.17) ; v1(168.22,25.34) 168.22,24.05 CN11.37
  ART06 w0.087: v1(189.74,65.17) 189.74,64.84 189.93,64.65 189.93,63.96 187.92,61.95 187.92,60.91 184.92,57.92 183.63,57.92 180.75,55.04 180.75,51.92 167.51,38.69 167.51,34.69 166.95,34.13 166.95,28.48 167.04,28.39 167.47,28.39 167.55,28.31 167.55,28.13 167.47,28.05 167.04,28.05 166.95,27.96 166.95,27.79 167.04,27.7 167.47,27.7 167.55,27.61 167.55,27.44 167.47,27.35 167.04,27.35 166.95,27.27 166.95,25.73 167.34,25.34 v1(168.22,25.34)
M_A_DQ<27>: length 55.8
  TOP w0.109: v1(164.5,30.38) 164.65,30.38 164.97,30.71 CN11.24 ; v1(188.8,67.73) 188.7,67.79 U1.BW38
  ART06 w0.087: v1(188.8,67.73) 188.25,67.18 188.25,65.66 188.05,65.46 188.05,63.82 187.07,62.84 186.37,62.84 185.2,61.68 185.2,60.95 184.66,60.41 184.32,60.41 183.34,59.43 181.87,59.43 178.77,56.33 178.77,54.88 177.99,54.11 177.99,51.99 163.86,37.86 163.86,36.28 163.96,36.19 164.13,36.19 164.21,36.27 164.21,37.64 164.3,37.72 164.47,37.72 164.56,37.64 164.56,31.79 164.12,31.36 164.12,30.66 164.4,30.38 v1(164.5,30.38)
M_A_DQ<28>: length 56.9
  TOP w0.109: v1(189.72,67.73) 189.63,67.79 U1.BV38 ; CN11.42 169.47,29.2 169.39,29.12 169.07,29.12 v1(168.97,29.21)
  ART06 w0.087: v1(189.72,67.73) 189.91,67.73 190.26,67.38 190.26,65.67 190.48,65.46 190.48,63.71 188.99,62.22 188.99,59.85 186.45,57.31 184.33,57.31 182.41,55.39 182.41,53.82 181.78,53.19 181.78,51.63 168.91,38.76 168.91,38.17 168.99,38.08 169.26,38.08 169.34,38 169.34,37.82 169.26,37.74 168.99,37.74 168.91,37.65 168.91,37.48 168.99,37.39 169.26,37.39 169.34,37.31 169.34,37.13 169.26,37.05 168.99,37.05 168.91,36.96 168.91,36.79 168.99,36.7 169.26,36.7 169.34,36.61 169.34,36.44 169.26,36.35 168.99,36.35 168.91,36.27 168.91,36.09 168.99,36.01 169.26,36.01 169.34,35.92 169.34,35.75 169.26,35.66 168.99,35.66 168.91,35.57 168.91,35.4 168.99,35.31 169.26,35.31 169.34,35.23 169.34,35.05 169.26,34.97 169.11,34.97 168.91,34.76 168.91,31.63 169.38,31.15 169.38,29.62 v1(168.97,29.21)
M_A_DQ<29>: length 55.2
  TOP w0.109: U1.BW39 188.66,67.18 v1(188.8,67.1) ; CN11.25 165.22,25.21 v1(165.1,25.33)
  ART06 w0.087: v1(165.1,25.33) 164.73,25.7 164.73,26.92 164.13,27.51 164.13,28.85 164.88,29.59 164.88,38.47 178.28,51.87 178.28,53.99 178.98,54.69 178.98,56.07 182.14,59.24 183.4,59.24 184.3,60.14 184.73,60.14 188.22,63.62 188.22,65.37 188.42,65.57 188.42,66.71 v1(188.8,67.1)
M_A_DQ<30>: length 53.3
  TOP w0.109: CN11.28 165.97,30.22 164.53,28.78 v1(164.53,28.71) ; v1(188.78,65.81) 188.77,65.81 188.76,65.85 U1.BW42
  ART06 w0.087: v1(188.78,65.81) 188.78,65.69 188.39,65.3 188.39,63.54 184.81,59.97 184.38,59.97 183.45,59.04 182.18,59.04 179.17,56.03 179.17,54.31 178.65,53.79 178.65,51.83 165.17,38.35 165.17,28.76 164.88,28.47 164.74,28.47 164.53,28.68 v1(164.53,28.71)

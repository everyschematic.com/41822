# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB2_ID: length 1.1
  TOP w0.076: v1(172.21,83.08) 172.2,83.1 U1.DL6
  BOTTOM w0.075: R7.1 172.19,83.07 v1(172.21,83.08)
USB2_OC<0>: length 206.3
  TOP w0.075: U1.DW14 v1(167.72,79.64) 167.57,79.79 166.56,79.79 R609.2
  TOP w0.102: v1(42.82,67.77) 42.77,67.82 42.77,68.14 41.77,69.14 41.77,75.13 42.59,75.95 42.59,79.87 43.33,80.61 43.33,85.25 34.41,94.17 26.09,94.17 23.72,96.54 23.72,105.74 24.32,106.34 25.2,106.34 26.09,107.23 26.09,110.96 25.55,111.5 R916.1
  TOP w0.203: R916.1 20.88,112.23 R917.2 20.11,113.01 C6147.1 19.56,112.32 U11.3
  ART03 w0.075: v1(167.72,79.64) 167.33,80.04 162.52,80.04 162.21,79.73 161.97,79.73
  ART03 w0.102: 161.97,79.73 158.07,79.73 155.29,76.95 148.43,76.95 147.91,77.47 145,77.47 144.45,76.92 141.32,76.92 140.6,76.21 140.6,75.1 138.98,73.48 137.01,73.48 134.29,70.76 127.39,70.76 124.9,68.27 124.9,67.4 123.78,66.27 123.78,66.26 123.49,65.96 123.47,65.96 122.85,65.34 116.46,65.34 115.35,64.23 101,64.23 100.02,63.25 81.86,63.25 81.58,63.53 78.76,63.53 76.95,65.34 73.54,65.34 73.27,65.61 65.07,65.61 64.52,66.15 63.39,66.15 62.9,66.65 61.09,66.65 60.17,67.56 58.09,67.56 57.8,67.27 56.54,67.27 55.83,66.56 52.79,66.56 52.28,67.06 44.3,67.06 42.86,67.66 v1(42.82,67.77)
USB2_OC<1>: length 210.8
  TOP w0.076: v1(181.23,66.49) 181.12,66.55 U1.CR41
  TOP w0.102: v1(38.13,106.62) 37.99,106.75 R920.2
  TOP w0.203: R919.1 36.16,107.22 C6148.1 37.22,107.17 R920.2 37.99,107.55 38.46,108.02 U22.3
  ART06 w0.102: v1(181.23,66.49) 180.98,66.49 180.81,66.32 180.81,64.17 178.95,62.32 178.18,62.32 177.59,61.72 177.59,60.89 175.16,58.45 173.95,58.45 171.71,56.22 171.71,53.92 166.5,48.71 155.78,48.71 155.27,49.22 151.02,49.22 149.96,50.28 146.85,50.28 142.84,54.29 139.19,54.29 133.47,60.01 125.15,60.01 123.57,61.58 118.86,61.58 117.4,60.12 114.44,60.12 114.07,60.48 113.49,60.48 112.49,59.48 109.45,59.48 108.41,60.52 103.52,60.52 102.57,61.47 93.4,61.47 91.22,59.29 81.38,59.29 79.34,61.33 75.21,61.33 74.37,60.49 72.34,60.49 71.82,61.01 61.01,61.01 59.43,62.59 55.01,62.59 53.43,64.17 53.43,70.58 53.22,70.79 52.64,70.79 52.38,70.53 48.67,70.53 48.34,70.86 46.63,70.86 44.67,72.83 44.67,73.92 43.38,75.2 43.38,77.01 42.29,78.1 42.29,79.44 43.64,80.8 43.64,83.75 39.57,87.81 39.57,106.23 39.13,106.67 38.19,106.67 v1(38.13,106.62)
  BOTTOM w0.075: v1(181.23,66.49) 180.76,66.02 180.76,64.72 R610.2
USB2_OC<2>: length 250.4
  TOP w0.076: U1.CT41 180.2,66.55 v1(180.32,66.49)
  ART06 w0.102: v1(53.49,96.83) 50.39,93.72 43.11,93.72 40.62,91.24 40.62,88.01 44.97,83.66 44.97,81.03 43.21,79.26 43.21,78.24 44.18,77.26 44.18,75.36 45.38,74.16 45.38,73.22 47.01,71.58 49.22,71.58 49.52,71.28 51.18,71.28 51.97,72.08 54.42,72.08 54.97,71.52 54.97,64.17 56.1,63.05 59.6,63.05 61.18,61.47 71.64,61.47 72,61.83 79.93,61.83 81.95,59.81 90.67,59.81 93.46,62.6 102.32,62.6 103.42,61.5 108.48,61.5 109.93,60.06 112.28,60.06 113.17,60.95 114.27,60.95 114.68,60.53 117.21,60.53 118.82,62.14 123.01,62.14 v1(123.24,62.38) 123.76,62.38 124.57,61.56 133.44,61.56 138.23,56.77 138.23,55.95 139.37,54.8 142.93,54.8 147.03,50.7 151.53,50.7 151.95,50.27 154.81,50.27 155.95,49.13 166.32,49.13 171.29,54.1 171.29,56.39 173.75,58.86 174.99,58.86 177.18,61.05 177.18,61.89 178.01,62.72 178.78,62.72 179.31,63.25 179.89,63.83 179.89,66.14 180.25,66.49 v1(180.32,66.49)
  BOTTOM w0.075: R927.2 179.92,65.49 179.92,65.96 180.32,66.35 v1(180.32,66.49)
  BOTTOM w0.102: U27.3 53.48,98.63 R926.2 ; v1(123.24,62.38) 124.03,62.38 128.95,57.45 128.95,55.7 128.06,54.8 128.06,51.23 128.76,50.52 135.53,50.52 136.4,49.65 136.4,48 136.08,47.68 134.77,47.68 134.24,48.21 126.25,48.21 R931.1 124.95,48.88 R932.2 123.52,49.27 U41.3 123.24,49.49 C6156.1 ; C6154.1 52.27,97.8 R925.1 52.27,97.33 R926.2 ; R926.2 53.48,96.84 v1(53.49,96.83)
USB2_OC<3>: length 220.5
  TOP w0.076: v1(180.32,65.19) U1.CT43
  TOP w0.102: v1(50.37,106.63) 51.06,106.63 52.09,107.66 R929.1
  TOP w0.203: R929.1 52.42,108.2 R930.2 53.2,108.21 C6155.1 53.2,109.37 52.91,109.65 U29.3
  ART06 w0.102: v1(180.32,65.19) 180.32,63.98 178.86,62.52 178.09,62.52 177.38,61.81 177.38,60.97 175.07,58.66 173.86,58.66 171.51,56.3 171.51,54.01 166.41,48.91 155.86,48.91 154.71,50.07 151.68,50.07 151.27,50.48 146.94,50.48 142.84,54.58 139.24,54.58 137.81,56.01 137.81,56.76 133.82,60.75 132.83,60.75 132.43,60.35 125.31,60.35 123.77,61.89 118.88,61.89 117.32,60.33 114.53,60.33 114.13,60.73 113.38,60.73 112.46,59.81 109.73,59.81 108.5,61.04 103.43,61.04 102.16,62.31 93.71,62.31 90.91,59.52 81.73,59.52 79.62,61.62 72.24,61.62 71.85,61.24 61.1,61.24 59.52,62.82 55.17,62.82 53.79,64.2 53.79,70.63 53.39,71.02 52.53,71.02 52.3,70.79 48.83,70.79 48.55,71.08 46.82,71.08 44.87,73.03 44.87,74 43.59,75.28 43.59,77.14 42.54,78.19 42.54,79.37 44.49,81.32 44.49,83.19 39.78,87.9 39.78,106.47 40.53,107.21 42.42,107.21 43.01,106.62 50.36,106.62 v1(50.37,106.63)
  BOTTOM w0.075: v1(180.32,65.19) 179.54,64.42 R928.2
USB2_P1_PWREN: length 43.7
  TOP w0.203: R490.2 56.54,109.02 U29.4 ; R490.2 56.65,108.03 55,106.38 53.79,106.38 50.22,102.81 v1(50.22,101.86) ; R490.2 57.41,109.02 R492.1
  ART03 w0.203: v1(50.22,101.86) 50.16,101.8 50.16,92.4 47.49,89.73 47.49,82.01 48.44,81.06 v1(48.44,80.75)
  BOTTOM w0.102: U27.4 52.93,101.19 R449.2 52.33,101.86 R485.1 ; v1(48.44,80.75) 48.44,80.65 48.41,80.62 48.41,79.54 48.56,79.38 U9.82
  BOTTOM w0.203: R485.1 51.04,102.68 v1(50.22,101.86)
USB2_VBUSSENSE: length 6.8
  TOP w0.075: v1(167.1,80.58) 167.08,80.61 R73.1
  TOP w0.076: v1(172.25,80.29) 172.52,80.56 U1.DL11
  ART06 w0.075: v1(167.1,80.58) 167.2,80.68 171.85,80.68 v1(172.25,80.29)
USB3_P1_PWREN: length 80.3
  TOP w0.102: R918.2 16.03,113.41 16.96,114.34 24.35,114.34 26.55,112.14 26.55,108.87 27.59,107.83 28.59,107.83 30.92,105.5 v1(30.92,104.25) ; R918.2 16.03,112.74 16.62,112.15 U11.4 ; R918.2 15.3,113.04 R232.1
  ART06 w0.102: v1(52.63,65.95) 52.52,66.06 52.52,67.29 49.89,69.91 48.1,69.91 47.56,70.45 46.27,70.45 44.15,72.57 44.15,73.85 42.9,75.1 42.9,76.85 41.76,77.99 41.76,79.51 43.18,80.93 43.18,82.06 42.6,82.64 41.87,82.64 41.43,83.07 41.43,85.1 34.39,92.14 34.39,102.37 32.52,104.25 v1(30.92,104.25)
  BOTTOM w0.102: U9.5 52.56,63.31 52.56,63.31 52.56,65.71 52.63,65.78 v1(52.63,65.95)
USB3_P2_PWREN: length 53.1
  TOP w0.102: v1(41.26,106.66) 41.66,107.06 R478.2 ; R478.2 42.12,107.27 R482.1 ; R478.2 41.66,108.32 41.61,108.37 U22.4
  ART06 w0.152: v1(54.44,71.44) 54.04,71.84 52.2,71.84 51.39,71.03 49.15,71.03 48.86,71.32 46.95,71.32 45.1,73.18 45.1,74.1 45.09,74.11 45.09,74.13 43.95,75.27 43.95,77.14 42.81,78.28 42.81,79.28 44.73,81.21 44.73,83.54 40.25,88.02 40.25,105.64 v1(41.26,106.66)
  BOTTOM w0.203: U9.108 54.66,71.65 v1(54.44,71.44)
USB3_RX_DN<1>: length 193.6
  TOP w0.076: v1(173.51,82.14) 173.72,82.35 arc(173.79,82.46) U1.DJ8
  ART06 w0.087: v1(173.51,82.14) 173.48,82.14 172.78,82.83 172.78,83.4 172.37,83.81 171.37,83.81 170.86,84.32 170.86,86.52 170.15,87.24 168.66,87.24 165.99,89.91 162.34,89.91 162.32,89.89 161.91,89.89 160.87,90.92 160.87,93.05 162.04,94.22 162.04,97.62 161.68,97.97 159.94,97.97 159.5,98.42 159.5,100.04 149.84,109.7 138.45,109.7 137.89,110.27 133.31,110.27 133.2,110.38 120.03,110.38 118.03,108.38 103.68,108.38 102.03,110.03 77.51,110.03 75.32,112.21 66.5,112.21 62.53,108.25 53.02,108.25 52.54,107.77 45.72,107.77 44.84,108.64 41.66,108.64 40.6,109.7 33.15,109.7 31.55,108.11 25.57,108.11 23.29,105.83 23.29,91.97 v1(23.71,91.56)
  BOTTOM w0.109: v1(23.71,91.56) 23.48,91.78 23.48,92.76 FIL2.4
USB3_RX_DN<1>_C: length 13.6
  BOTTOM w0.109: J1.5 15.79,102.79 16.79,101.79 17.56,101.79 19.37,99.97 19.88,99.97 20.02,100.11 D45.10 D45.1 21.32,100.11 21.46,99.97 21.83,99.97 23.31,98.49 23.31,95.5 FIL2.3
USB3_RX_DN<2>: length 187.3
  TOP w0.076: v1(174.29,82.42) 174.57,82.14 U1.DG9
  ART03 w0.075: 161.97,80.62 161.99,80.62 162,80.64 162.12,80.64 163.04,81.56 164.96,81.56 165.42,81.1 167.69,81.1 170.12,78.68 173.64,78.68 174.05,79.09 174.05,80.26 174.12,80.34 174.32,80.34 174.39,80.41 174.39,80.56 174.32,80.64 174.12,80.64 174.05,80.71 174.05,80.86 174.12,80.94 174.32,80.94 174.39,81.01 174.39,81.16 174.32,81.24 174.12,81.24 174.05,81.31 174.05,81.46 174.12,81.53 174.32,81.53 174.39,81.61 174.39,81.76 174.32,81.83 174.12,81.83 174.05,81.91 174.05,82.21 174.25,82.42 v1(174.29,82.42)
  ART03 w0.087: 161.97,80.62 157.89,80.62 156.96,79.7 156.11,79.7 154.1,77.69 148.73,77.69 147.71,78.71 145.26,78.71 144.02,77.48 141.06,77.48 140.03,76.45 140.03,75.64 138.61,74.21 137.07,74.21 134.1,71.25 127.21,71.25 124.98,69.02 123.7,69.02 120.73,66.04 116.36,66.04 115.17,64.86 107.88,64.86 107.54,65.2 106.34,65.2 105.72,65.82 101.65,65.82 99.63,63.81 82.42,63.81 82.2,64.03 79.25,64.03 77.44,65.85 74.32,65.85 74.09,66.08 70.27,66.08 69.72,66.63 63.59,66.63 63.09,67.13 61.31,67.13 60.37,68.07 56.53,68.07 55.53,67.07 53.51,67.07 53,67.59 47.83,67.59 47.12,68.3 42.09,68.3 41.74,67.95 39.19,67.95 38.54,67.29 38.54,66.37 38.59,66.32 38.94,66.32 v1(39.12,66.49)
  BOTTOM w0.109: R480.1 34.39,93.56 34.39,78.47 34.14,78.22 34.14,72.08 36.2,70.02 36.2,68.22 38.09,66.33 38.95,66.33 v1(39.12,66.49)
USB3_RX_DN<2>_C: length 12.9
  BOTTOM w0.109: FIL10.3 34.38,96.08 34.38,98.24 33.15,99.47 32.26,99.47 32.12,99.61 D29.1 D29.10 30.84,99.61 30.72,99.49 30.21,99.49 27.95,101.75 27.57,101.75 26.51,102.81 J2.5
USB3_RX_DP<1>: length 193.7
  TOP w0.076: v1(173.51,82.96) 173.5,83.06 arc(173.5,83.09) 173.52,83.13 173.82,83.5 U1.DJ6
  ART06 w0.087: v1(23.1,91.56) 23.1,105.91 25.49,108.29 31.48,108.29 33.07,109.89 40.67,109.89 41.74,108.82 44.92,108.82 45.79,107.95 52.47,107.95 52.95,108.43 62.46,108.43 66.42,112.39 75.4,112.39 77.59,110.21 102.11,110.21 103.76,108.56 117.95,108.56 119.95,110.56 133.27,110.56 133.38,110.45 137.96,110.45 138.53,109.88 149.91,109.88 159.68,100.12 159.68,98.49 160.02,98.16 161.76,98.16 162.22,97.69 162.22,94.14 161.06,92.98 161.06,91 161.98,90.07 166.06,90.07 168.73,87.4 170.22,87.4 171.02,86.59 171.02,84.39 171.44,83.97 172.44,83.97 172.95,83.46 172.95,82.9 173.15,82.7 173.26,82.7 v1(173.51,82.96)
  BOTTOM w0.109: v1(23.1,91.56) 23.26,91.72 23.26,92.8 FIL2.1
USB3_RX_DP<1>_C: length 13.5
  BOTTOM w0.109: J1.6 15.77,101.17 15.77,101.99 15.91,102.12 16.14,102.12 16.7,101.57 17.47,101.57 19.28,99.75 19.85,99.75 19.99,99.61 D45.9 D45.2 21.4,99.61 21.54,99.75 21.74,99.75 23.1,98.4 23.1,95.12 FIL2.2
USB3_RX_DP<2>: length 187.3
  TOP w0.076: v1(174.26,83.1) 174.57,82.79 U1.DG7
  ART03 w0.075: v1(174.26,83.1) 173.9,82.7 173.9,82.28 173.9,82.28 173.9,79.15 173.58,78.84 170.18,78.84 167.76,81.26 165.48,81.26 165.02,81.72 162.98,81.72 162.06,80.79 162,80.79 161.98,80.81 161.97,80.81
  ART03 w0.087: v1(39.12,65.89) 38.87,66.13 38.51,66.13 38.35,66.29 38.35,67.37 39.11,68.13 41.66,68.13 42.02,68.48 47.19,68.48 47.91,67.77 53.08,67.77 53.59,67.26 55.45,67.26 56.45,68.25 60.45,68.25 61.39,67.31 63.16,67.31 63.66,66.81 69.8,66.81 70.35,66.27 74.17,66.27 74.4,66.03 77.51,66.03 79.33,64.22 82.27,64.22 82.5,63.99 99.56,63.99 101.57,66.01 105.79,66.01 106.42,65.38 107.62,65.38 107.95,65.05 115.1,65.05 116.28,66.23 120.66,66.23 123.63,69.2 124.9,69.2 127.13,71.43 134.03,71.43 137,74.4 138.53,74.4 139.85,75.71 139.85,76.53 140.99,77.66 143.95,77.66 145.18,78.9 147.79,78.9 148.81,77.88 154.03,77.88 156.04,79.88 156.89,79.88 157.81,80.81 161.97,80.81
  BOTTOM w0.109: R481.1 34.17,93.55 34.17,78.56 33.92,78.31 33.92,71.99 35.98,69.93 35.98,68.13 38,66.11 38.9,66.11 v1(39.12,65.89)
USB3_RX_DP<2>_C: length 12.9
  BOTTOM w0.109: FIL10.2 34.17,96.08 34.17,98.15 33.06,99.25 32.29,99.25 32.15,99.11 D29.2 D29.9 30.77,99.11 30.62,99.26 30.13,99.26 27.86,101.53 27.48,101.53 26.89,102.12 26.67,102.12 26.51,101.96 J2.6
USB3_TX_DN<1>: length 193
  TOP w0.076: v1(172.33,87.56) 172.33,87.66 arc(172.38,87.8) 172.52,87.86 172.51,87.85 172.63,87.83 arc(172.65,87.82) 172.67,87.82 arc(172.68,87.81) 172.68,87.81 172.69,87.8 arc(172.7,87.75) 172.71,87.7 172.71,86.85 arc(172.72,86.76) 172.78,86.68 172.97,86.5 173.01,86.45 173.02,86.45 173.1,86.37 173.1,85.92 173.26,85.77 173.41,85.74 173.43,85.71 173.48,85.7 arc(173.54,85.68) 173.59,85.65 173.61,85.63 U1.DJ2
  ART06 w0.087: v1(21.15,90.73) 20.73,91.15 20.73,95.31 22.24,96.82 22.24,105.96 25.05,108.77 31.19,108.77 32.99,110.57 41.11,110.57 42.37,109.31 47.96,109.31 48.9,110.24 54.95,110.24 56.3,108.9 62.26,108.9 66.24,112.88 75.64,112.88 77.84,110.68 82.83,110.68 83.79,111.64 85.43,111.64 85.77,111.31 86.97,111.31 87.6,110.68 118.16,110.68 119.09,111.61 121.61,111.61 122.16,111.06 133.56,111.06 133.72,110.91 139.54,110.91 139.69,111.06 149.52,111.06 162.89,97.69 162.89,94.02 161.53,92.66 161.53,91.34 162.24,90.63 162.97,90.63 162.99,90.65 166.64,90.65 169.56,87.73 172.16,87.73 v1(172.33,87.56)
  BOTTOM w0.109: v1(21.15,90.73) 21.28,90.86 C233.2
USB3_TX_DN<1>_C: length 12
  BOTTOM w0.109: FIL3.3 21.08,95.26 21.08,96.02 22.26,97.2 22.26,98.21 22,98.47 21.49,98.47 21.35,98.61 D45.4 D45.7 20,98.61 19.87,98.49 19.24,98.49 17.57,96.82 16.79,96.82 16.37,96.4 16.07,96.4 15.79,96.67 J1.8
USB3_TX_DN<2>: length 186.8
  TOP w0.076: v1(172.34,89.42) 172.66,89.74 arc(172.68,89.76) 172.71,89.76 172.72,89.76 arc(172.79,89.74) 172.81,89.67 172.81,89.65 arc(172.86,89.38) 172.98,89.13 arc(173.02,89.07) 173.04,88.99 173.04,87.23 arc(173.09,86.99) 173.22,86.79 173.5,86.51 arc(173.62,86.44) 173.75,86.41 arc(173.83,86.38) 173.87,86.29 173.87,86.06 arc(173.86,86) 173.84,85.94 arc(173.8,85.76) 173.85,85.58 arc(173.88,85.51) 173.88,85.43 173.81,85.19 arc(173.72,85.11) 173.6,85.13 arc(173.48,85.15) 173.37,85.1 arc(173.35,85.08) 173.34,85.07 arc(173.33,84.96) 173.4,84.87 arc(173.5,84.83) U1.DJ3
  ART03 w0.075: 162.61,90.18 162.69,90.18 162.7,90.2 170.21,90.2 170.47,90.46 171.19,90.46 171.77,89.88 171.94,89.88 172.01,89.81 172.01,89.75 v1(172.34,89.42)
  ART03 w0.087: 162.61,90.18 160.27,90.18 160.17,90.09 156.62,90.09 155.72,89.19 143.62,89.19 142.41,87.97 132.08,87.97 121.81,77.7 121.81,76.06 117.96,72.22 113.2,72.22 111.35,70.37 107.77,70.37 107.51,70.11 96.63,70.11 94.03,67.51 86.58,67.51 85.36,68.73 83.14,68.73 81.43,70.44 80.02,70.44 77.65,72.81 67.16,72.81 66.21,73.75 61.05,73.75 60.66,73.36 60,73.36 58.55,71.91 52.06,71.91 51.27,71.12 49.26,71.12 48.79,71.58 43.18,71.58 42.41,72.36 38.82,72.36 35.1,68.64 34.08,68.64 33.68,69.04 33.68,70.02 34.08,70.42 34.41,70.42 v1(34.61,70.62)
  BOTTOM w0.109: C386.2 31.77,90.94 31.77,89.05 33.4,87.42 33.4,70.8 33.58,70.62 v1(34.61,70.62)
USB3_TX_DN<2>_C: length 11.1
  BOTTOM w0.109: J2.8 27.2,96.46 27.3,96.46 27.83,96.99 29.01,96.99 29.99,97.97 30.65,97.97 30.79,98.11 D29.7 D29.4 32.1,98.11 32.25,97.97 32.71,97.97 32.94,97.73 32.94,97.1 31.77,95.93 31.77,95.26 FIL11.3
USB3_TX_DP<1>: length 193
  TOP w0.076: U1.DJ1 173.61,85.95 arc(173.57,85.92) 173.52,85.9 173.47,85.91 173.44,85.89 173.33,85.91 173.26,85.99 173.26,86.43 173.13,86.55 173.13,86.56 173.08,86.61 172.89,86.8 arc(172.88,86.83) 172.87,86.86 172.87,87.7 arc(172.86,87.78) 172.84,87.86 arc(172.83,87.88) 172.82,87.9 172.81,87.91 arc(172.8,87.92) 172.78,87.94 arc(172.77,87.95) 172.75,87.96 172.71,87.99 arc(172.69,87.99) 172.68,88 172.56,88.02 arc(172.53,88.03) 172.51,88.05 172.37,88.13 arc(172.34,88.16) v1(172.33,88.2)
  ART06 w0.087: v1(20.54,90.73) 20.54,95.38 22.06,96.89 22.06,106.04 24.97,108.95 31.12,108.95 32.92,110.75 41.19,110.75 42.45,109.49 47.89,109.49 48.82,110.43 55.03,110.43 56.37,109.09 62.18,109.09 66.16,113.06 75.72,113.06 77.92,110.86 82.75,110.86 83.72,111.83 85.51,111.83 85.84,111.49 87.05,111.49 87.67,110.86 118.08,110.86 119.01,111.79 121.68,111.79 122.23,111.25 133.64,111.25 133.8,111.09 139.46,111.09 139.62,111.25 149.6,111.25 163.08,97.77 163.08,93.94 161.71,92.58 161.71,91.42 162.32,90.82 166.71,90.82 169.63,87.89 172.02,87.89 v1(172.33,88.2)
  BOTTOM w0.109: C234.2 20.5,90.77 v1(20.54,90.73)
USB3_TX_DP<1>_C: length 12.1
  BOTTOM w0.109: FIL3.2 20.86,95.41 20.86,96.11 22.05,97.3 22.05,98.12 21.91,98.25 21.5,98.25 21.36,98.11 D45.5 D45.6 20,98.11 19.85,98.27 19.33,98.27 17.66,96.6 16.88,96.6 16.46,96.18 16.01,96.18 15.79,95.96 J1.9
USB3_TX_DP<2>: length 186.8
  TOP w0.076: U1.DJ5 173.8,84.41 arc(173.87,84.51) 173.9,84.63 arc(173.92,84.78) 173.93,84.92 arc(173.93,84.93) 173.93,84.93 arc(173.94,85.04) 173.96,85.15 173.98,85.21 174.04,85.38 arc(174.05,85.54) 173.99,85.68 arc(173.96,85.77) 173.98,85.86 arc(174.02,85.96) 174.03,86.06 174.03,86.29 arc(173.95,86.49) 173.75,86.57 arc(173.68,86.59) 173.62,86.63 173.34,86.91 arc(173.24,87.06) 173.21,87.23 173.21,88.99 arc(173.18,89.13) 173.11,89.24 arc(173.01,89.44) 172.98,89.65 arc(172.9,89.85) 172.7,89.93 172.65,89.93 arc(172.48,89.96) v1(172.34,90.05)
  ART03 w0.075: v1(172.34,90.05) 172.32,90.03 171.83,90.03 171.26,90.61 170.41,90.61 170.15,90.35 162.65,90.35 162.63,90.37 162.61,90.37
  ART03 w0.087: 162.61,90.37 160.19,90.37 160.1,90.27 156.55,90.27 155.65,89.37 143.55,89.37 142.33,88.16 132,88.16 121.62,77.78 121.62,76.14 117.88,72.4 113.12,72.4 111.28,70.56 107.69,70.56 107.43,70.29 96.55,70.29 93.96,67.7 86.65,67.7 85.43,68.92 83.21,68.92 81.5,70.63 80.09,70.63 77.73,72.99 67.23,72.99 66.29,73.94 60.98,73.94 60.59,73.55 59.93,73.55 58.47,72.09 51.98,72.09 51.19,71.3 49.33,71.3 48.87,71.76 43.26,71.76 42.48,72.54 38.74,72.54 35.02,68.82 34.16,68.82 33.86,69.12 33.86,69.94 34.16,70.24 34.39,70.24 v1(34.61,70.02)
  BOTTOM w0.109: C387.2 31.55,90.91 31.55,88.96 33.18,87.33 33.18,70.71 33.49,70.4 34.22,70.4 v1(34.61,70.02)
USB3_TX_DP<2>_C: length 11.1
  BOTTOM w0.109: J2.9 26.51,95.53 27.22,96.24 27.39,96.24 27.92,96.77 29.1,96.77 30.08,97.75 30.63,97.75 30.75,97.62 31.02,97.62 D29.6 D29.5 32.11,97.61 32.25,97.75 32.62,97.75 32.73,97.64 32.73,97.2 31.55,96.02 31.55,95.24 FIL11.2
VCLK: length 2.6
  TOP w0.203: U7.12 90.65,87.75 89.58,88.82 C23.1 C24.1
VNN_BYPASS: length 1.2
  TOP w0.3: U1.CY34 178.15,69.86 v1(178.48,69.64)
  BOTTOM w0.305: R99.2 178.32,69.8 v1(178.48,69.64)
VR_ALERT#: length 6.6
  BOTTOM w0.102: R242.1 228.34,96.74 226.12,98.96 224.94,98.96 224.1,99.8 U3.5
VR_VCLK: length 4.5
  BOTTOM w0.109: R235.1 226.03,97.6 225.47,98.16 224.75,98.16 223.3,99.61 U3.7
VR_VDIO: length 5.6
  BOTTOM w0.109: U3.6 223.7,99.73 224.86,98.57 225.77,98.57 227.43,96.9 R239.1
VREF: length 76.3
  TOP w0.203: v1(188.81,102.05) 188.62,102.24 PR100.2
  ART03 w0.305: v1(219.72,100.88) 219.13,100.29 215.86,100.29 215.6,100.02 v1(215.6,99.13) 215.6,98.77 216.43,97.93 222.26,97.93 222.83,98.5 225.23,98.5 226.15,97.57 226.15,92.01 v1(227.49,90.68)
  ART03 w0.508: v1(219.72,100.88) 219.72,103.42 221.66,105.36 225.05,105.36 226.07,106.37 226.07,109.84 226.58,110.36 v1(226.58,110.48)
  ART06 w0.203: v1(188.81,102.05) 188.99,101.87 190.5,101.87 193.43,98.94 215.41,98.94 v1(215.6,99.13)
  BOTTOM w0.203: 220.18,101.92 220.44,102.19 U3.14
  BOTTOM w0.305: v1(226.58,110.48) 226.16,110.91 PR94.2 ; PR103.2 215.63,99.16 v1(215.6,99.13) ; PR7.2 PR8.2 225.16,90.68 PR9.2 227.36,90.8 v1(227.49,90.68) ; PR81.2 219.61,100.82 219.67,100.88 v1(219.72,100.88) 219.78,100.94 219.78,101.53 220.18,101.92
VREF_CA: length 9.2
  TOP w0.305: CN11.164 v1(201.97,30.86)
  BOTTOM w0.305: R732.1 204.57,33.45 R167.1 205.91,32.23 R128.1
  BOTTOM w0.508: R732.1 204.22,33.54 R730.2 202.61,33.3 C886.2 201.76,31.63 C885.2 201.96,30.87 v1(201.97,30.86)
VREFA: length 3.7
  BOTTOM w0.305: U37.12 32.81,47.8 C512.2 33.36,47.36 R537.2
VRHOT: length 6.6
  BOTTOM w0.102: U3.4 224.5,99.99 225.29,99.21 226.22,99.21 229.12,96.3 R259.1
VSPI: length 2
  BOTTOM w0.203: U9.106 56.53,72.45 56.94,72.87 R48.2
WIFI_CLK_REQ#: length 45
  TOP w0.076: U1.DN34 v1(171.56,69.39)
  TOP w0.102: v1(147.88,86.21) 143.91,86.21 R145.2 ; R16.2 161.56,69.67 163.38,69.67 v1(163.66,69.4)
  ART06 w0.102: v1(147.88,86.21) 148.61,85.48 148.61,83.49 148.91,83.19 150.31,83.19 151.06,82.45 151.06,76.49 157.1,70.45 157.3,70.45 159.49,68.25 160.01,68.25 160.7,68.94 161.49,68.94 162.2,69.65 163.4,69.65 v1(163.66,69.4) 163.66,69.93 163.95,70.22 165.64,70.22 165.95,69.91 171.04,69.91 v1(171.56,69.39)
WIFI_DISABLE#: length 114.2
  TOP w0.102: R330.2 44.02,75.2 45.73,76.92 45.73,77.76 46.3,78.33 46.3,78.76 v1(46.43,78.9) ; v1(122.84,88.24) 122.84,88.49 123.54,89.19 123.54,92.29 124.33,93.07 126.42,93.07 126.66,93.31 127.47,93.31 127.68,93.53 R240.1 127.69,93.79 R276.1 127.88,94.35 130.32,94.35 131.34,95.37 133.11,95.37 CN22.54
  ART06 w0.102: v1(46.43,78.9) 46.75,79.22 48.37,79.22 48.69,78.9 52.16,78.9 52.75,78.32 54.69,78.32 55.01,77.99 61.37,77.99 62.54,79.16 64.16,79.16 66.59,76.73 80.22,76.73 81.06,75.88 83.64,75.88 84.64,76.88 84.64,81.68 87.35,84.39 87.35,89.41 89.13,91.18 119.89,91.18 v1(122.84,88.24)
WIFI_PCIE_CLK_DN: length 63.3
  TOP w0.076: U1.CL2 182.38,85.68 182.64,85.95 182.64,86.52 182.05,87.11 182.05,89.77 182.22,89.94 v1(182.86,89.94)
  TOP w0.109: v1(144.23,101.9) 144.06,102.07 143.82,102.07 142.72,100.97 142.72,97.27 142.28,96.83 141.7,96.83 141.49,96.61 CN22.49
  ART03 w0.075: v1(182.86,89.94) 182.64,90.15 182.45,90.15 182.28,90.32 182.28,93.72 182.6,94.03 182.6,97.54 182.58,97.55 182.58,97.57
  ART03 w0.087: v1(144.23,101.9) 144.4,102.08 145.07,102.08 145.45,102.46 158.69,102.46 158.95,102.21 173.37,102.21 174.1,101.48 177.34,101.48 177.7,101.12 180.71,101.12 182.58,99.26 182.58,97.57
WIFI_PCIE_CLK_DP: length 63.3
  TOP w0.076: U1.CL1 182.48,86.21 182.48,86.45 181.89,87.04 181.89,89.84 182.15,90.1 182.4,90.1 182.48,90.18 182.48,90.5 182.55,90.57 v1(182.86,90.57)
  TOP w0.109: v1(144.23,102.5) 144.01,102.29 143.73,102.29 142.51,101.07 142.51,97.37 142.19,97.05 141.53,97.05 141.46,97.11 CN22.47
  ART03 w0.075: v1(182.86,90.57) 182.78,90.5 182.59,90.3 182.51,90.3 182.43,90.38 182.43,93.66 182.75,93.97 182.75,97.54 182.76,97.55 182.76,97.57
  ART03 w0.087: 182.76,97.57 182.76,99.33 180.79,101.3 177.77,101.3 177.41,101.66 174.17,101.66 173.45,102.39 159,102.39 158.74,102.65 145.38,102.65 144.99,102.26 144.47,102.26 v1(144.23,102.5)
WIFI_POWERON: length 94.4
  ART06 w0.152: v1(46.03,76.42) 46.4,76.05 50.5,76.05 51.62,77.18 54.13,77.18 54.59,76.72 62.09,76.72 66.82,71.99 80.86,71.99 82.61,73.75 85.08,73.75 87.29,75.95 87.29,80.59 89.79,83.09 94.34,83.09 95.32,84.07 119.98,84.07 120.51,83.54 122.21,83.54 v1(122.74,84.07)
  BOTTOM w0.152: v1(46.03,76.42) 46.17,76.56 46.17,76.86 46.16,76.87 U9.76
  BOTTOM w0.203: v1(122.74,84.07) 124.67,86.01 R246.1 124.42,87.85 U14.3
WIRELESS_ON: length 133.3
  TOP w0.102: v1(123.44,88.29) 124.22,89.08 124.22,92.17 124.68,92.63 127.36,92.63 128.82,94.09 130.65,94.09 131.43,94.86 CN22.56
  ART06 w0.102: v1(56.79,66.84) 56.03,67.6 56.03,72.94 55.09,73.89 51.58,73.89 50.58,72.89 48.09,72.89 47.82,72.62 47.21,72.62 46.31,73.53 46.31,74.11 45.04,75.38 45.04,77.71 45.27,77.94 45.27,79.31 45.65,79.68 46.03,79.68 47.25,80.91 47.65,80.91 48.35,80.21 48.35,79.55 48.8,79.11 52.27,79.11 52.85,78.53 54.76,78.53 55.1,78.2 61.24,78.2 62.5,79.45 64.28,79.45 66.63,77.1 82.91,77.1 84.24,78.44 84.24,81.79 86.97,84.52 86.97,89.39 89.03,91.45 120.29,91.45 v1(123.44,88.29)
  BOTTOM w0.102: U9.119 56.32,67.25 56.74,66.84 v1(56.79,66.84)
WLAN_PCIE_RST: length 73.5
  TOP w0.076: v1(173.43,68.38) 173.43,68.27 173.17,68.01 U1.DK38
  ART03 w0.102: v1(139.6,67.21) 140.46,66.35 149.13,66.35 150.48,67.7 156.75,67.7 157.15,68.11 158.33,68.11 158.73,67.71 161.59,67.71 161.68,67.8 161.68,68.31 161.98,68.61 163.43,68.61 164.13,67.91 171.53,67.91 172.39,68.77 173.08,68.77 173.43,68.43 v1(173.43,68.38)
  ART06 w0.102: v1(125.84,92.16) 126.34,91.65 129.51,91.65 138.21,82.94 138.21,68.87 138.24,68.84 138.24,68.57 v1(139.6,67.21)
  BOTTOM w0.102: U10.2 125.46,94.41 R248.1 125.32,94.51 125.77,94.07 125.77,92.23 v1(125.84,92.16)
WLAN_PCIE_WAKE#: length 95.4
  TOP w0.102: R150.2 161.75,60.16 R422.2 161.72,59.92 161.46,59.66 160.68,59.66 160.02,58.99 160.02,56.79 159.14,55.92 v1(159.14,55.54) ; v1(126.55,86.07) 126.87,85.75 135.86,85.75 137.87,87.75 141.47,87.75 141.74,88.03 141.74,94.98 141.61,95.11 CN22.55 ; v1(130.3,91.78) 130.71,91.36 CN22.70
  ART03 w0.102: v1(130.3,91.78) 130.3,91.43 126.9,88.03 126.9,86.42 v1(126.55,86.07)
  ART06 w0.102: v1(159.14,55.54) 158.08,55.54 157.25,54.71 153.42,54.71 152.46,55.68 151.19,55.68 150.87,55.35 150.22,55.35 149.67,55.89 145.54,55.89 143.83,57.6 143.83,58.59 139.39,63.03 137.77,63.03 135.12,65.68 135.12,65.82 133.59,67.35 133.59,78.85 126.55,85.9 v1(126.55,86.07)
WLAN_PLT_RST: length 5.4
  TOP w0.102: v1(131.03,95.82) 131.19,95.82 131.23,95.86 CN22.52
  BOTTOM w0.102: U10.4 128.74,95.06 129.51,95.82 v1(131.03,95.82)
  BOTTOM w0.305: U10.4 128.26,94.89 R244.2
WLAN_WAKE_N: length 26.4
  TOP w0.076: U1.DJ38 v1(173.51,67.55)
  TOP w0.102: 159.22,67.74 159.24,67.71 159.24,66.76 157.59,65.12 157.59,62.73 160.19,60.13 R422.1 ; 159.22,67.74 R875.2 ; 159.22,67.74 R876.1 160.6,68.31 v1(160.63,68.31)
  ART06 w0.102: v1(173.51,67.55) 172.32,67.55 172.2,67.68 168.94,67.68 168.59,68.03 167,68.03 165.71,69.33 164.28,69.33 163.97,69.02 163.35,69.02 163.08,69.3 162.22,69.3 161.58,68.66 160.97,68.66 v1(160.63,68.31)
WRST#: length 3.8
  BOTTOM w0.102: U9.14 48.96,60.77 48.53,60.34 48.53,59.56 C8.2 47.63,59.45 R238.1
XCLK_BIASREF: length 5.9
  TOP w0.075: R20.1 169.6,87.23 169.68,87.23 170.55,86.36 170.55,85.8 170.67,85.69 170.67,84.64 170.52,84.5 170.16,84.5 169.73,84.07 U1.DU6
XTAL1: length 8.4
  BOTTOM w0.127: X2.1 63.48,70.9 66.65,70.9 C413.1 67.49,70.8 68.2,70.8 68.46,70.53 U30.28
XTAL2: length 6.8
  BOTTOM w0.127: X2.3 65.27,71.18 66.66,71.18 C1.1 67.57,71.2 68.29,71.2 68.56,70.93 U30.29
XTAL24_IN: length 9.7
  TOP w0.127: X1.3 164.61,87.81 164.88,87.53 164.88,86.3 C11.1 164.65,86.05 165.1,85.59 165.1,84.14 R17.1 165.14,83.32 165.37,83.22 166.48,83.22 167.31,82.4 168.3,82.4 U1.DW8
XTAL24_OUT: length 11.6
  TOP w0.127: 165.84,86.04 165.37,85.57 165.37,84.03 R17.2 166.29,83.74 167.43,82.61 169.19,82.61 169.53,82.26 U1.DU8 ; 165.84,86.04 C13.1 ; 165.84,86.04 165.75,86.04 165.11,86.68 165.11,88.51 X1.1
N457881: length 4.6
  TOP w0.109: R440.2 129.44,91.8 R281.2 132.08,92.57 132.37,92.86 133.12,92.86 CN22.64
N500287: length 3.5
  TOP w0.203: R206.1 C352.2 147.38,98.99 147.01,98.62 U24.9
N500381: length 4.4
  TOP w0.203: C351.1 R208.1 ; R208.1 145.8,99.28 146.56,98.53 U24.10 ; R208.1 R211.1
N500393: length 3.6
  TOP w0.203: C349.2 144.26,99.54 144.56,99.23 145.07,99.23 146.11,98.2 U24.11
N500423: length 3.7
  TOP w0.203: U24.12 145.66,97.96 144.75,98.87 144.17,98.87 143.5,99.54 R204.1
N501011: length 0.6
  TOP w0.406: C335.2 143.22,95.72
N501069: length 1.3
  TOP w0.305: C351.2 146.57,100.75 R6.1
N501253: length 1.2
  TOP w0.203: 145.11,96.5 U24.1
  TOP w0.406: 145.11,96.5 145.08,96.54 R5.1
N501257: length 1.3
  TOP w0.406: C335.1 143.96,98.04 R5.2
N775277: length 3.9
  TOP w0.203: U25.27 26.87,81.65
  TOP w0.254: 26.87,81.65 26.4,81.65
  TOP w0.305: C458.1 24.39,83.06 R389.2 25.8,81.65 26.4,81.65
N775289: length 2.6
  TOP w0.203: U25.34 27.2,78.85
  TOP w0.305: 27.2,78.85 25.78,77.42 C457.1
N775381: length 8.2
  TOP w0.152: v1(27.51,77.22) 27.58,77.3 28.34,77.3 U25.37
  TOP w0.305: v1(21.98,74.69) 21.99,74.69 C467.2
  ART03 w0.305: v1(27.51,77.22) 24.97,74.69 v1(21.98,74.69)
N775429: length 3.6
  TOP w0.203: U25.28 26.77,81.25 26.69,81.16 25.07,81.16 C456.2
N775503: length 1.2
  TOP w0.305: C470.2 30.54,87.42 R824.2
N775969: length 6.3
  TOP w0.203: C467.1 23.21,76.71 26.27,76.71 26.51,76.96 26.51,77.61 27.35,78.45 U25.35
N776445: length 187.4
  TOP w0.203: v1(22.2,88.84) 22.8,88.24 22.8,86.43 21.92,85.56 21.92,81.07 22.71,80.28 R392.1 R391.1
  TOP w0.305: v1(130.48,113.01) 131,113.53 132.4,113.53 134.6,111.33 137.19,111.33 138.49,112.63 150.13,112.63 D65.N 151.11,112.75 C6125.1 151.87,112.63 ACN1.1 ; R825.1 R824.1
  TOP w0.508: R824.1 31.11,90.15 31.14,90.19 v1(31.14,90.25)
  ART06 w0.254: v1(130.48,113.01) 129.47,114.02 112.36,114.02 111.46,113.13 90.51,113.13 89.87,113.77 85.58,113.77 84.93,113.13 83.39,113.13 82.19,111.93 78.45,111.93 76.32,114.06 65.75,114.06 62.52,110.83 56.45,110.83 55.18,112.1 34.19,112.1 33.08,113.21 23.39,113.21 20.14,109.96 20.14,98.55 19.31,97.72 19.31,90.17 19.95,89.52 21.51,89.52 v1(22.2,88.84) 22.56,89.2 22.56,89.85 23.01,90.3 31.09,90.3 v1(31.14,90.25)
N776559: length 1.8
  TOP w0.109: U25.3 34.21,78.85 R407.1
N776571: length 6.3
  TOP w0.203: U25.36 27.53,78.05
  TOP w0.305: FB17.1 23.91,74.9 C461.2 25.12,76.2 C462.2 26.48,76.22 26.98,76.73 26.98,77.5 27.53,78.05
N776947: length 1.9
  TOP w0.109: U25.2 33.76,78.45 34.9,77.31 R406.2
N777173: length 1.8
  TOP w0.203: R408.2 34.71,78.87 34.33,79.25 U25.4
N777797: length 3.9
  TOP w0.102: R400.2 34.7,84.74 33.49,83.54 U25.12
N777825: length 5.8
  TOP w0.102: R401.2 37.51,84.28 34.8,84.28 34.15,83.62 34.15,82.45 33.74,82.05 U25.11
N777887: length 2.3
  TOP w0.203: U25.7 34.41,80.45 34.88,80.91 C487.2
N777931: length 1.8
  TOP w0.102: U25.48 32.79,76.94 33.42,76.31 R397.2
N778447: length 1.2
  TOP w0.305: R423.2 FB34.2
N778451: length 1.2
  TOP w0.305: R425.2 FB35.2
N778639: length 9.4
  TOP w0.203: R396.2 R398.2 38.57,86.54 35.93,86.54 32.79,83.4 U25.13
N778927: length 1.2
  TOP w0.305: C471.2 29.3,87.43 R825.2
N778973: length 4.6
  TOP w0.203: 30.14,84.22 29.99,84.07 U25.20
  TOP w0.508: 30.14,84.22 30.18,84.22 31.6,85.63 31.6,86.8 R393.1
N779045: length 4.9
  TOP w0.203: U25.19 30.39,83.76 32.15,85.52 32.15,86.13 C475.2
N779197: length 5.1
  TOP w0.102: U25.16 31.59,83.58 31.92,83.9 32.3,83.9 33.36,84.95 33.36,85.85 34.1,86.59 C479.2
N779371: length 26.4
  TOP w0.305: v1(8.73,91.48) 8.89,91.64 8.89,94.08 9.57,94.75 12.88,94.75 14.53,93.1 14.53,92.32 16.12,90.72 18.94,90.72 21,92.79 24.39,92.79 26.3,90.89 27.73,90.89 28.09,90.53 R823.1
N1014091: length 3.3
  BOTTOM w0.203: U54.1 158.62,55.07 R353.2 158.33,55.34 R192.1 158.88,56.41 R354.2
N1016161: length 1.4
  TOP w0.203: U21.6 159.63,88.85 C281.2
N1016367: length 12.6
  TOP w0.203: R365.1 155.31,87.75 v1(155.04,88.01)
  BOTTOM w0.305: v1(155.04,88.01) 155.04,87.91 151.63,84.49 D69.N 151.3,84.6 151.3,85.75 150.85,86.2 150.61,86.2 149.63,87.18 147.49,87.18 146.74,86.43 D68.N
N1016683: length 43.4
  BOTTOM w0.203: R895.1 160.83,53.17 U54.4 161.03,53.81 161.23,54.01 162.36,54.01 163.43,55.09 163.43,55.51 162.69,56.24 161.42,56.24 160.84,56.83 160.84,57.35 159.89,58.3 158.61,58.3 158.14,58.77 158.14,59.3 155.27,62.17 155.27,66.25 155.83,66.81 155.83,68.09 155.83,68.09 155.83,68.62 154.08,70.38 154.08,70.74 153.2,71.62 150.4,71.62 149.06,72.97 149.06,79.07 149.92,79.94 150.35,79.94 151.3,80.89 151.3,82.09 D69.P
N1017638: length 1.2
  TOP w0.203: U21.3 156.06,88.85 v1(155.98,88.77) 155.9,88.7 R365.2
  BOTTOM w0.203: v1(155.98,88.77) R902.2
N1064435: length 13
  TOP w0.076: U1.CH47 184.21,63.38 184.21,62.83 184.34,62.54 184.34,61.21 184.16,61.03 184.16,59.65 183.64,59.13 183.64,57.64 182.58,56.58 182.58,55.58 181.03,54.02 180.36,54.02 v1(180.36,54.03)
  BOTTOM w0.305: v1(180.36,54.03) 180.36,54.02 180.71,54.02 181.08,54.39 R369.1
N1064561: length 12.1
  TOP w0.075: 182.4,60.29 180.4,58.3 180.4,57.8 178.39,55.79 v1(178.39,55.6)
  TOP w0.076: U1.CL48 182.66,63 182.4,62.46 182.4,62.37 182.39,62.36 182.39,61.14 182.4,61.13 182.4,60.29
  BOTTOM w0.075: v1(178.39,55.6) 178.98,56.19 R370.1
N1065581: length 13.5
  TOP w0.076: U1.DK21 v1(172.77,75.68)
  TOP w0.102: R374.1 161.32,77.03 v1(161.4,76.95)
  ART03 w0.075: v1(172.77,75.68) 172.76,75.68 172.43,75.35 168.92,75.35 168.12,76.15 165.27,76.15 165.25,76.17
  ART03 w0.102: 165.25,76.17 162.49,76.17 161.72,76.95 v1(161.4,76.95)
N1170111: length 14.2
  BOTTOM w0.109: J1.2 17.29,98.76 16,100.05 15.09,100.05 14.73,100.41 14.73,103.72 15.18,104.16 19.9,104.16 D21.N 20.35,104.61 R424.2
N1170159: length 1.2
  BOTTOM w0.109: FIL3.1 20.79,92.8 20.79,92.55 C234.1
N1170163: length 14.2
  BOTTOM w0.109: J1.3 17.55,99.89 17.55,99.2 17.47,99.12 17.23,99.12 16.09,100.27 15.18,100.27 14.95,100.5 14.95,103.62 15.27,103.94 19.8,103.94 D22.N 20.36,103.38 R427.2
N1170323: length 1.2
  BOTTOM w0.109: C233.1 21,92.54 21,92.8 FIL3.4
N1274442: length 15.2
  BOTTOM w0.203: U2.16 115.59,55.19 115.84,55.45
  BOTTOM w0.406: C130.2 123.33,55.27 124.18,54.41 125.76,54.41 127.66,56.31 v1(128.5,56.31)
  BOTTOM w0.635: v2(122.23,57.93) 118.78,57.93 116.76,55.9 116.29,55.9 115.84,55.45
N1320662: length 0.6
  TOP w0.076: U1.DP21 171.22,76.05 v1(170.88,75.71)
N1407597: length 2.6
  BOTTOM w0.305: R444.1 60.04,88.19 R445.1 59.4,89.04 58.69,89.75 D7.N
N1637434: length 3.8
  TOP w0.102: R462.1 130.38,99.36 CN22.38
N1637496: length 5.6
  TOP w0.109: R463.1 127.79,98.12 129.94,98.12 130.69,98.86 CN22.40
N1637500: length 5.7
  TOP w0.109: R464.1 128.11,97.68 129.88,97.68 130.56,98.36 CN22.42
N1726762: length 15.2
  TOP w0.076: v1(173.63,75.73) U1.DJ22
  TOP w0.102: v1(160.59,76.96) 160.54,77.01 160.54,77.63 R177.1
  ART03 w0.075: 165.21,75.95 167.99,75.95 168.75,75.19 173.07,75.19 173.61,75.73 v1(173.63,75.73)
  ART03 w0.102: 165.21,75.95 162.45,75.95 161.9,76.5 161.05,76.5 v1(160.59,76.96)
N2010639: length 1.9
  TOP w0.203: C30.2 92.6,89.15 92,88.55 U7.9
N2010982: length 1.5
  TOP w0.406: 88.71,86.17 88.71,86.53 ; 88.71,86.53 89.01,86.23 ; 88.71,86.53 88.71,86.53 ; 88.41,86.23 88.71,86.53 ; 88.71,86.53 C17.2
N2400754: length 5.4
  BOTTOM w0.203: R121.1 R123.1 111.4,50.3 C197.1 111.43,50.85 111.9,51.31 111.9,52.08 112.79,52.96 U2.6
N2447682: length 19.2
  BOTTOM w0.109: J2.2 28.01,98.93 27.9,99.04 27.73,99.04 26.8,99.98 25.97,99.98 25.49,99.5 25.14,99.5 D27.N 24.45,99.12 24.35,99.23 24.35,99.39 24.24,99.5 24.13,99.5 23.92,99.5 23.49,99.93 23.49,101.33 24.4,102.24 25.17,102.24 25.36,102.43 25.36,103.8 25.78,104.23 28.5,104.23 30.48,102.24 31.2,102.24 FIL9.3 31.73,102.77 R477.2
N2447732: length 1
  BOTTOM w0.109: C387.1 31.17,92.25 FIL11.1
N2447742: length 19
  BOTTOM w0.109: R479.2 31.74,101.5 FIL9.2 31.22,102.02 30.39,102.02 28.41,104.01 25.87,104.01 25.58,103.71 25.58,102.34 25.26,102.02 24.49,102.02 23.71,101.24 23.71,100.02 24.02,99.72 24.13,99.72 24.24,99.72 24.35,99.83 24.35,100 24.45,100.1 D28.N 25.14,99.72 25.4,99.72 25.88,100.2 26.89,100.2 27.82,99.26 28.16,99.26 28.39,99.49 28.39,99.77 J2.3
N2447932: length 1
  BOTTOM w0.109: C386.1 32.17,92.28 FIL11.4
N2461741: length 12.3
  TOP w0.109: J4.3 48.08,99.84 47.73,99.48 46.76,99.48 46.05,98.76 46.05,90.84 D34.N 45.66,90.45 FIL4.3
N2461749: length 12.8
  TOP w0.109: J4.2 48.08,98.9 47.73,99.26 46.85,99.26 46.27,98.67 46.27,98.15 46.38,98.04 46.46,98.04 46.57,97.93 46.57,97.71 46.46,97.6 46.37,97.6 46.27,97.49 46.27,90.86 D35.N 46.66,90.46 FIL4.2
N2465511: length 5.8
  BOTTOM w0.109: FIL14.3 41.97,99.25 41.67,99.25 D36.N 40.95,99.24 38.27,99.24 J5.3
N2465519: length 5.8
  BOTTOM w0.109: FIL14.2 41.98,99.03 41.69,99.03 D37.N 40.94,99.02 38.24,99.02 J5.2
N2477813: length 2.1
  BOTTOM w0.305: R197.1 C191.2 U4.4
N2478393: length 4.3
  BOTTOM w0.097: R500.1 72.79,101.86 72.45,101.86 71.23,103.08 70.95,103.08 70.76,102.89 70.76,102.5 70.53,102.27 LJ1.7
N2478475: length 5
  BOTTOM w0.097: R499.1 73.8,98.35 73.8,98.78 72.85,99.73 LJ1.5
N2478521: length 1.3
  BOTTOM w0.102: U18.2 R362.1
N2478581: length 5.6
  BOTTOM w0.097: LJ1.6 68.97,99.67 67.36,99.67 66.78,99.09 66.78,98.29 FIL16.2
N2478589: length 7.8
  BOTTOM w0.097: R494.1 68.83,92.31 68.83,92.95 69.28,93.4 71.09,93.4 71.61,93.92 71.61,95.34 71.36,95.58 71.07,95.58 70.89,95.4 70.89,95.09 70.45,94.65 LJ1.1
N2478593: length 7.8
  BOTTOM w0.097: R495.1 69.18,92.36 69.18,92.81 69.43,93.06 71.24,93.06 71.95,93.78 71.95,95.48 71.5,95.92 LJ1.2
N2478743: length 6.4
  BOTTOM w0.097: 69.06,99.33 67.5,99.33 67.13,98.95 67.13,98.26 FIL16.3 ; 69.43,97.19 LJ1.3
  BOTTOM w0.102: 69.43,97.19 69.25,97.38 69.25,99.14 69.06,99.33
N2478981: length 5
  BOTTOM w0.097: R498.1 73.46,98.26 73.46,98.64 72.71,99.39 71.09,99.39 70.93,99.24 70.93,98.9 70.5,98.46 LJ1.4
N2479001: length 3.7
  BOTTOM w0.097: LJ1.8 70.42,103.43 71.37,103.43 72.59,102.21 72.87,102.21 R505.1
N2492664: length 19.8
  TOP w0.305: R822.1 26.34,90.15 24.25,92.24 21.25,92.24 19.15,90.15 R418.1 15.88,90.15 13.51,92.52 D54.N 12.12,92.52 C501.2 10.47,92.48 J7.3
N2496341: length 9.9
  TOP w0.102: R508.2 34.5,90.38 35.7,89.19 35.7,87.76 R507.2 34.88,85.89 32.39,83.4 U25.14
N2500362: length 3.3
  BOTTOM w0.102: CN14.5 222.81,35 221.79,36.02 R221.2
N2500386: length 3.5
  BOTTOM w0.102: D38.N 221.6,34.67 221.82,34.45 221.82,33.91 222.34,33.4 CN14.1
N2500440: length 13.4
  BOTTOM w0.102: CN14.18 231.24,43.4 227.32,39.47 222.67,39.47 221.19,38 R421.1
N2500754: length 17.4
  BOTTOM w0.102: R509.1 R426.1 220.92,39.91 226.76,39.91 228.39,41.54 228.39,46.12 228.83,46.56 231.9,46.56 CN14.26
N2500852: length 17
  BOTTOM w0.102: CN14.20 230.93,44.2 230.44,43.71 229.91,43.71 229.23,43.03 229.23,42.02 226.9,39.68 222.41,39.68 221.19,38.47 219.01,38.47 218.85,38.3 ; R1395.1 218.85,38.3 ; 218.85,38.3 R1396.1
N2500964: length 8.6
  TOP w0.102: R510.1 231.68,42.08 231.34,42.42 231.34,43.66 231.07,43.93 230.4,43.93 230.04,44.29 230.04,47.4 230.26,47.62 v1(230.32,47.62)
  BOTTOM w0.102: v1(230.32,47.62) 230.38,47.62 230.6,47.4 CN14.28
N2501616: length 18.1
  BOTTOM w0.102: CN14.2 232.47,33.26 232.47,30.07 231.54,29.15 230.68,29.15 228.74,31.09 227.68,31.09 226.03,32.73 222.28,32.73 221.81,32.26 R59.2 221.38,32.26 R62.1
N2501758: length 2.2
  TOP w0.102: R516.2 231.32,48.6 R517.1 231.54,48.39 U33.2
N2502048: length 2.1
  TOP w0.102: R513.2 230.75,51.15 R514.2 230.75,51.98 U32.4
N2505593: length 4.8
  TOP w0.305: R569.2 22.3,39.08 23.5,40.28 CN20.5 26.2,40.28 R564.1
N2505601: length 4.5
  TOP w0.305: R570.1 23.17,37.79 23.65,38.28 CN20.7 26.21,38.28 R565.1
N2505967: length 6.3
  TOP w0.305: R567.2 22.24,41.62 22.8,42.18 22.8,43.7 23.38,44.28 CN20.1 26.19,44.28 R562.1
N2505977: length 5.1
  TOP w0.305: R563.1 26.19,42.28 CN20.3 23.9,42.28 22.02,40.39 R568.2
N2506213: length 0.9
  BOTTOM w0.305: C509.2 34.12,45.8 R533.2
N2506315: length 43
  TOP w0.305: v1(60.5,37.62) 60.55,37.62 62.53,35.64 Q34.2
  ART06 w0.305: v1(37.37,46.42) 37.37,41.76 41.52,37.62 v1(60.5,37.62)
  BOTTOM w0.305: R552.1 34.04,49.71 34.7,50.37 R551.2 R539.2 R538.2 38.58,48.97 R543.2 37.37,47.59 v1(37.37,46.42)
N2507261: length 36.5
  TOP w0.305: Q34.1 v1(60.6,39.33)
  ART06 w0.305: v1(36.64,48.42) 38.38,46.67 38.38,41.73 41.73,38.38 59.66,38.38 v1(60.6,39.33)
  BOTTOM w0.305: v1(36.64,48.42) 36.18,48.87 R547.2
N2514339: length 3.3
  BOTTOM w0.254: R576.1 58.84,11.19 R579.1 59.6,11.17 R580.1 ; R576.1 58.75,11.1 U39.3 ; R576.1 58.86,11.16 R582.1
N2514863: length 35.1
  ART03 w0.102: v1(50.53,29.94) 50.53,32.54 48.13,34.95 46.04,34.95 38.42,42.57 34.69,42.57 33.88,43.38 v1(25.9,43.38)
  BOTTOM w0.102: v1(25.9,43.38) 25.95,43.32 R585.2 ; R586.2 R587.2 50.25,30.22 v1(50.53,29.94) U42.45
N2515735: length 2.7
  BOTTOM w0.102: R595.1 44.94,13.87 PR107.2 44.34,13.26 U43.7
N2516175: length 2.8
  BOTTOM w0.102: TP59.1 51.64,19.96 52.93,21.25 U42.20
N2516589: length 1.4
  BOTTOM w0.203: 55.27,21.41 54.93,21.74 U42.15 ; U42.16 54.53,21.35
N2517121: length 1
  BOTTOM w0.254: U39.6 55.47,11.1 55.27,10.9 C518.2
N2567475: length 3
  TOP w0.102: R273.2 112.74,59.61 Q40.3 112.74,60.38 R364.2 111.91,61.66 R210.1
N2631851: length 5.2
  TOP w0.075: 183.18,60.79 183.18,60.29 R125.1
  TOP w0.076: U1.CL47 182.65,63.42 182.89,63.18 182.89,62.93 182.87,62.87 182.86,62.81 182.86,62.54 182.87,62.53 182.89,62.5 182.89,62.22 182.78,62.12 182.78,61.57 183.18,61.17 183.18,60.79
N2631888: length 5.8
  TOP w0.075: R142.1 182.91,58.58 182.91,59.45 183.52,60.06 183.52,61.43 183.7,61.6 183.7,61.89 183.66,61.93 183.52,62.07 183.52,62.84 183.28,63.08 U1.CK47
N2631892: length 8
  TOP w0.076: R143.1 182.7,59.12 182.7,59.49 183.35,60.14 183.35,61.23 182.98,61.6 182.98,62.09 183.05,62.15 183.05,62.51 183.04,62.6 183.04,62.86 183.06,62.97 183.06,63.09 183.05,63.22 182.99,63.37 182.99,63.72 U1.CK46
N2631896: length 9
  TOP w0.075: 183.12,59.3 183.12,57.96 181.86,56.7 R144.1
  TOP w0.076: 183.12,59.3 183.68,59.85 183.68,61.23 183.86,61.41 183.86,62.02 183.67,62.22 183.67,62.48 183.71,62.59 183.71,62.84 183.64,62.97 183.59,63.1 183.59,64.01 U1.CH45
N2652017: length 3.6
  TOP w0.102: R161.2 129.77,100.86 133.12,100.86 CN22.32
N2652021: length 3.6
  TOP w0.102: R164.2 129.81,100.36 CN22.34
N2652047: length 3.7
  TOP w0.102: CN22.36 130.1,99.86 R166.2
N2652167: length 3.9
  TOP w0.102: R264.2 130.54,97.36 CN22.46
N2652171: length 4.1
  TOP w0.102: R274.2 129.67,95.63 130.9,96.86 CN22.48
N2652197: length 3.8
  TOP w0.102: R263.2 129.96,97.22 130.62,97.88 133.1,97.88 CN22.44
N2652755: length 4.1
  TOP w0.102: R158.2 129.62,102.02 130.5,102.02 131.84,103.36 CN22.22
N2653101: length 4.5
  TOP w0.102: R275.2 129.94,94.86 130.22,95.13 130.22,95.67 130.91,96.36 CN22.50
N2655807: length 11.1
  TOP w0.102: CN22.53 141.8,95.61 142.13,95.28 142.13,86.75 R145.1
N3254610:
  vias: v2(103.28,98.11) v2(103.28,97.34) v2(103.28,96.58)
N3254616:
  vias: v2(98.24,97.81) v2(98.25,97.1) v2(98.26,98.52)
N3431626: length 1.3
  TOP w0.075: C6059.1 209.36,90.19 209.36,90.53 209.36,90.66 209.23,90.79 TP35.1
N3431630: length 1.4
  TOP w0.075: TP36.1 209.65,90.8 209.51,90.67 209.51,90.53 209.52,90.2 C6060.1
N3431634: length 1.2
  TOP w0.102: C6061.1 211.99,90.38 212.32,90.7 TP37.1
N3431638: length 1.3
  TOP w0.102: C6062.1 211.73,90.54 212,90.81 TP38.1
N3521964: length 6.6
  BOTTOM w0.203: C401.2 120.3,73.82 120.1,73.62 119.46,73.62 119.27,73.42 Q86.3 R815.2
  BOTTOM w0.305: C401.2 121.52,74.21 Q74.4
N3521976: length 11.6
  BOTTOM w0.203: R816.2 118.53,70.72 Q86.1 118.53,72.1 118.25,72.38 117.3,72.38 117.05,72.63 117.05,75.58 Q76.3 119.4,76.48 120.3,75.58 R791.2
N4072078: length 1.5
  TOP w0.305: U7.1 90.24,86.83 R33.1
N4072093: length 1
  TOP w0.406: R33.2 C17.1
N5760544: length 5.5
  TOP w0.076: U1.CV39 v1(179.4,67.1)
  BOTTOM w0.075: v1(179.4,67.1) 179.39,67.1 178.98,66.69 178.98,65.69 177.75,64.45 177.06,64.45 R3.2
N5761208: length 11.1
  TOP w0.075: R58.1 163.84,79.03 v1(163.55,79.31)
  TOP w0.076: U1.DK17 v1(172.86,77.63)
  ART03 w0.102: v1(172.86,77.63) 172.5,77.99 170,77.99 169.05,78.95 166.88,78.95 166.59,79.24 163.63,79.24 v1(163.55,79.31)
N5765083: length 124.9
  TOP w0.076: v1(174.04,86.96) 174.26,87.18 174.31,87.18 175.21,86.28 175.21,85.49 175.21,85.37 175.21,85.37 175.25,84.84 U1.DE4
  ART03 w0.075: 170.08,57.42 170.09,57.43 170.09,57.45 172.56,59.92 173.89,59.92 175.34,61.37 175.34,61.96 176,62.62 176,64.66 176.25,64.91 176.25,69.94 177.08,70.78 177.08,71.34 177.58,71.84 177.58,77.36 174.83,80.11 174.83,84.94 174.49,85.28 174.49,85.38 174.52,85.41 174.52,85.54 174.43,85.63 174.31,85.63 174.28,85.6 174.17,85.6 174.07,85.7 174.07,85.81 174.11,85.86 174.11,85.95 174.01,86.06 173.89,86.06 173.85,86.02 173.75,86.02 173.57,86.2 173.57,87.07 173.68,87.18 173.83,87.18 v1(174.04,86.96)
  ART03 w0.087: 170.08,57.42 167.49,54.84 167.49,53.84 165.29,51.64 163.88,51.64 163.08,50.83 162.56,50.83 159.07,47.34 159.07,45.09 v1(159.28,44.88)
  BOTTOM w0.109: v1(159.28,44.88) 159.14,44.74 159.14,44.61 159.21,44.54 162.32,44.54 162.72,44.14 171.92,44.14 176.05,48.27 186.49,48.27 188.57,46.2 207.11,46.2 209.19,48.27 216.74,48.27 219.89,51.42 220.16,51.42 C3.1
N5765087: length 125
  TOP w0.076: U1.DE3 175.65,85.14 175.72,85.21 175.72,85.35 175.61,85.46 175.45,85.46 175.36,85.55 175.36,85.55 175.36,86.35 174.38,87.33 174.28,87.33 v1(174.04,87.57)
  ART03 w0.075: v1(174.04,87.57) 173.81,87.33 173.62,87.33 173.42,87.13 173.42,86.14 174.68,84.87 174.68,80.04 177.43,77.29 177.43,71.9 176.93,71.4 176.93,70.84 176.1,70.01 176.1,64.97 175.85,64.72 175.85,62.68 175.19,62.02 175.19,61.43 173.83,60.07 172.5,60.07 169.98,57.56 169.96,57.56 169.95,57.55
  ART03 w0.087: v1(158.68,44.88) 158.89,45.09 158.89,47.41 162.49,51.01 163,51.01 163.81,51.82 165.21,51.82 167.31,53.92 167.31,54.91 169.95,57.55
  BOTTOM w0.109: v1(158.68,44.88) 158.92,44.64 158.92,44.52 159.12,44.32 162.23,44.32 162.63,43.93 172.01,43.93 176.14,48.05 186.4,48.05 188.48,45.98 207.2,45.98 209.28,48.05 216.83,48.05 219.98,51.21 220.25,51.21 C12.1
N5765191: length 126.1
  TOP w0.076: U1.DD1 176.08,85.88 176.01,85.82 175.91,85.82 175.81,85.92 175.81,86.38 175,87.2 175,88.29 174.79,88.51 174.43,88.51 v1(174.22,88.73)
  ART03 w0.075: 171.52,57.42 171.53,57.43 171.53,57.46 173.34,59.26 174.03,59.26 175.97,61.2 175.97,61.76 177.59,63.38 177.59,64.45 177.18,64.85 177.18,66.4 177.22,66.43 177.22,70.02 178.24,71.05 178.24,72.64 178.81,73.2 178.81,76.94 175.24,80.51 175.24,86.51 174.75,87.01 174.75,88.33 174.6,88.47 174.47,88.47 v1(174.22,88.73)
  ART03 w0.087: 171.52,57.42 168.29,54.19 168.29,53.49 165.74,50.93 164.17,50.93 159.96,46.73 159.96,44.02 v1(160.11,43.88)
  BOTTOM w0.109: C60.1 220.11,49.09 218.84,49.09 217.31,47.56 209.59,47.56 207.22,45.2 187.68,45.2 185.32,47.56 176.46,47.56 172.25,43.36 160.08,43.36 159.9,43.54 159.9,43.67 v1(160.11,43.88)
N5765195: length 126.1
  TOP w0.076: U1.DD2 176.08,85.56 176.01,85.64 175.84,85.64 175.66,85.82 175.66,86.32 174.85,87.13 174.85,88.23 174.72,88.36 174.45,88.36 v1(174.22,88.12)
  ART03 w0.075: v1(174.22,88.12) 174.41,88.32 174.54,88.32 174.59,88.27 174.59,86.95 175.09,86.45 175.09,80.44 178.66,76.88 178.66,73.26 178.09,72.7 178.09,71.11 177.07,70.08 177.07,66.5 177.03,66.46 177.03,64.79 177.44,64.39 177.44,63.44 175.82,61.82 175.82,61.26 173.96,59.41 173.27,59.41 171.43,57.56 171.4,57.56 171.39,57.55
  ART03 w0.087: 171.39,57.55 168.11,54.27 168.11,53.56 165.66,51.11 164.09,51.11 159.78,46.8 159.78,44.15 v1(159.51,43.88)
  BOTTOM w0.109: C61.1 220.2,48.85 218.9,48.85 217.4,47.34 209.68,47.34 207.31,44.98 187.59,44.98 185.23,47.34 176.55,47.34 172.34,43.14 159.99,43.14 159.68,43.45 159.68,43.7 v1(159.51,43.88)
N5765627: length 139.3
  TOP w0.076: v1(173.72,89.06) 173.97,89.31 174.64,89.31 175.21,88.74 175.21,87.41 176.34,86.28 176.34,86.06 arc(176.33,86) 176.31,85.94 arc(176.27,85.76) 176.33,85.58 arc(176.36,85.51) 176.35,85.43 176.28,85.19 arc(176.19,85.11) 176.07,85.13 arc(175.95,85.15) 175.84,85.1 arc(175.83,85.08) 175.82,85.07 arc(175.8,84.96) 175.87,84.87 arc(175.97,84.83) U1.DD3
  ART03 w0.075: 172.39,57.55 172.41,57.56 172.43,57.56 173.53,58.66 174.33,58.66 177.1,61.43 177.1,62.56 177.8,63.25 177.8,64.75 177.95,64.9 177.95,69.96 178.6,70.62 178.6,72.64 179.07,73.1 179.07,77.05 175.45,80.67 175.45,86.74 174.93,87.26 174.93,88.95 174.77,89.1 174.67,89.1 174.63,89.06 174.51,89.06 174.41,89.16 174.41,89.28 174.45,89.31 174.45,89.42 174.37,89.51 174.09,89.51 174.02,89.43 174.02,89.36 v1(173.72,89.06)
  ART03 w0.087: v1(156.33,42.45) 156.64,42.14 159.15,42.14 160.66,43.65 160.66,46.7 164.4,50.44 166.28,50.44 168.83,52.98 168.83,53.98 172.39,57.55
  BOTTOM w0.109: C62.1 219.9,45.63 217.2,45.63 213.82,42.24 210.85,42.24 208.94,44.16 186.43,44.16 184.52,42.24 180.97,42.24 178.65,42.24 176.5,40.1 158.89,40.1 156.72,42.27 156.51,42.27 v1(156.33,42.45)
N5765631: length 139.5
  TOP w0.076: v1(173.72,89.66) 173.91,89.46 174.7,89.46 175.36,88.8 175.36,87.47 176.49,86.34 176.49,86.06 176.5,86.06 arc(176.49,85.96) 176.46,85.86 arc(176.43,85.77) 176.46,85.68 arc(176.52,85.54) 176.51,85.38 176.46,85.21 176.44,85.15 arc(176.41,85.04) 176.4,84.93 arc(176.4,84.93) 176.4,84.92 arc(176.39,84.78) 176.38,84.63 arc(176.35,84.51) 176.27,84.41 U1.DD5
  ART03 w0.075: 172.52,57.42 172.54,57.43 172.54,57.45 173.59,58.51 174.4,58.51 177.25,61.36 177.25,62.5 177.95,63.19 177.95,64.69 178.1,64.84 178.1,69.9 178.75,70.55 178.75,72.57 179.22,73.04 179.22,77.11 175.6,80.73 175.6,86.8 175.08,87.32 175.08,89.01 174.43,89.66 v1(173.72,89.66)
  ART03 w0.087: v1(156.33,41.85) 156.44,41.96 159.23,41.96 160.84,43.57 160.84,46.62 164.47,50.26 166.36,50.26 169.01,52.91 169.01,53.9 172.52,57.42
  BOTTOM w0.109: v1(156.33,41.85) 156.53,42.05 156.63,42.05 158.8,39.88 176.59,39.88 178.74,42.03 184.61,42.03 186.53,43.94 208.85,43.94 210.76,42.03 213.91,42.03 217.29,45.41 C66.1
N5765735: length 134.4
  TOP w0.076: U1.DA3 177.43,84.59 177.39,84.55 177.27,84.55 177.18,84.65 177.18,84.81 arc(177.19,84.92) 177.23,85.03 arc(177.25,85.13) 177.23,85.24 177.22,85.25 177.22,85.26 177.15,85.39 177.15,85.55 177.18,85.57 177.18,85.98 177.12,86.03 177.12,86.32 177.18,86.37 177.18,87 176.87,87.31 177.06,87.49 v1(177.13,87.49)
  ART03 w0.075: 173.6,57.42 173.61,57.43 173.61,57.45 173.84,57.69 174.3,57.69 177.78,61.17 177.78,62.22 178.46,62.9 178.46,64.36 179.03,64.93 179.03,69.97 179.8,70.74 179.8,77.22 176.55,80.48 176.55,85.75 177.13,86.33 177.13,87 176.92,87.22 176.92,87.28 v1(177.13,87.49)
  ART03 w0.087: v1(156.22,40.76) 156.01,40.55 155.91,40.55 155.73,40.72 155.73,40.94 156.07,41.27 159.49,41.27 161.54,43.32 161.54,46.29 164.72,49.47 166.69,49.47 172.71,55.49 172.71,56.54 173.6,57.42
  BOTTOM w0.109: C67.1 220.24,43.78 219.66,43.2 215.95,43.2 214.28,41.53 210.56,41.53 208.72,43.37 186.65,43.37 184.82,41.53 179.13,41.53 176.96,39.37 158.36,39.37 157.25,40.48 156.5,40.48 v1(156.22,40.76)
N5765739: length 134.6
  TOP w0.076: v1(176.52,87.49) 176.59,87.49 176.72,87.36 176.72,87.24 177.02,86.94 177.02,86.44 176.97,86.38 176.97,85.97 177.02,85.91 177.02,85.64 177,85.61 177,85.35 177.02,85.3 177.09,85.09 arc(177.04,84.95) 177.02,84.81 177.02,84.59 177.04,84.57 177.04,84.55 U1.DA5
  ART03 w0.075: v1(176.52,87.49) 176.77,87.25 176.77,87.15 176.98,86.94 176.98,86.39 176.4,85.81 176.4,80.42 179.65,77.16 179.65,70.8 178.88,70.03 178.88,64.99 178.31,64.42 178.31,62.97 177.63,62.28 177.63,61.23 174.24,57.84 173.78,57.84 173.5,57.56 173.48,57.56 173.47,57.55
  ART03 w0.087: 173.47,57.55 172.53,56.61 172.53,55.57 166.62,49.66 164.65,49.66 161.35,46.36 161.35,43.4 159.41,41.46 155.99,41.46 155.55,41.01 155.55,40.65 155.83,40.37 156.01,40.37 v1(156.22,40.16)
  BOTTOM w0.109: v1(156.22,40.16) 156.32,40.26 157.16,40.26 158.27,39.15 177.05,39.15 179.22,41.32 184.91,41.32 186.74,43.15 208.63,43.15 210.47,41.32 214.37,41.32 216.04,42.98 C133.1
N5766195: length 100.5
  TOP w0.076: U1.CW2 178.55,85.65 178.28,85.92 178.28,88.04 176.97,89.36 176.97,90.45 176.73,90.69 175.54,90.69 v1(175.32,90.47)
  TOP w0.109: C79.1 112.28,67.09 112.61,67.09 114.41,68.88 114.41,75.65 114.23,75.83 114.11,75.83 v1(113.85,75.56)
  ART03 w0.075: v1(175.32,90.47) 175.04,90.74 174.72,90.74 174.48,90.98 174.48,92.4 171.69,95.19 169.48,95.19 166.95,92.66 165.1,92.66 165.09,92.64 165.07,92.64
  ART03 w0.087: v1(113.85,75.56) 114.27,75.98 114.46,75.98 114.91,76.43 114.91,88.71 117.67,91.47 121.9,91.47 123.63,93.2 127.09,93.2 127.36,92.94 130.98,92.94 131.7,92.21 136.09,92.21 136.75,91.55 138.63,91.55 139.18,91 141.03,91 141.42,91.38 152.51,91.38 153.63,92.5 153.98,92.5 154.8,93.32 155.31,93.32 155.69,93.71 158.68,93.71 159.36,93.03 161.45,93.03 161.84,92.64 165.07,92.64

# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDA_SDATAOUT: length 145
  TOP w0.109: v1(147.02,55.31) R622.1 ; U25.5 34.83,79.65 34.96,79.78 C431.2 35.64,79.33 37.06,79.33 38.6,77.79 38.6,71.99 38.07,71.46 38.07,70.04 39.12,68.98 39.12,67.45 40.82,65.75 43.12,65.75 46.98,61.89 46.98,60.75 46.46,60.23 46.46,57.76 45.2,56.5 v1(45.2,53.87)
  ART03 w0.087: v1(45.2,53.87) 45.24,53.83 45.24,53.53 45.45,53.32 48.71,53.32 49.77,54.38 51.97,54.38 53.24,53.1 56.23,53.1 56.6,52.73 65.39,52.73 66.4,53.74 77.58,53.74 79.77,51.56 83.22,51.56 84.26,52.6 100,52.6 101.8,50.79 106.93,50.79 107.8,51.66 108.36,51.66 108.36,51.66 111.17,51.66 111.88,50.96 116.15,50.96 116.68,51.49 118.72,51.49 119,51.21 125.44,51.21 129.07,54.84 133.56,54.84 134.02,55.31 v1(147.02,55.31)
HDA_SDOUT: length 40.9
  TOP w0.076: U1.CY47 178.27,63.08 178.51,62.85 178.51,62.11 178.66,61.96 178.66,61.71 178.45,61.5 178.45,61.01 174.88,57.44
  TOP w0.109: R619.1 149.37,56.97 Q15.3 149.95,56.94 Q18.2 150.05,54.52 151.07,55.54 152.33,55.54 152.82,55.05 R260.1 152.85,55 153.76,55 155.85,52.91 163.08,52.91 163.58,52.41 172.04,52.41 174.88,55.26 174.88,57.44
HDA_SYNC: length 164.6
  TOP w0.109: v1(151.11,52.89) 151.7,52.89 R277.1 ; U25.10 33.82,81.65 34.71,82.54 34.71,83.49 35.01,83.79 37.98,83.79 C429.2 40.08,83.6 41.19,82.49 41.19,80.11 40.76,79.68 40.76,68.8 42.26,67.3 44.64,67.3 47.09,64.84 47.09,64.36 49.16,62.29 49.16,55.38 47.63,53.85 46.36,53.85 45.96,54.25 v1(45.96,54.52)
  ART03 w0.087: v1(45.96,54.52) 45.96,54.97 46.81,55.82 53.55,55.82 54,55.37 78.08,55.37 80.29,53.16 82.05,53.16 82.89,54 100.58,54 102.38,52.19 105.15,52.19 105.64,52.68 106.83,52.68 107.06,52.92 107.07,52.92 107.29,53.13 111.69,53.13 112.02,52.8 114.92,52.8 115.41,53.28 116.58,53.28 117.13,53.83 119.09,53.83 120.3,52.62 124.2,52.62 128.43,56.86 133.05,56.86 133.75,57.56 138.59,57.56 139.39,58.36 144.03,58.36 145.44,56.95 150.59,56.95 152.33,55.2 152.33,53.56 151.66,52.89 v1(151.11,52.89)
HDMI_CLK+: length 16.9
  TOP w0.109: FIL8.3 57.93,86.39 R217.1 58.31,86.78 58.31,87.11 57.79,87.64 56.93,87.64 56.33,88.24 56.33,88.76 56.17,88.93 D49.9 D49.2 56.17,90.28 56.28,90.4 56.28,92.8 54.78,94.3 54.78,98.16 55,98.37 55.3,98.37 55.74,98.81 CN3.10
HDMI_CLK-: length 16.5
  TOP w0.109: FIL8.2 58.93,86.37 R217.2 58.53,86.77 58.53,87.2 57.88,87.85 57.02,87.85 56.55,88.33 56.55,88.81 56.67,88.92 D49.10 D49.1 56.67,90.25 56.5,90.41 56.5,92.89 55,94.39 55,98.07 55.09,98.15 55.32,98.15 55.66,97.81 CN3.12
HDMI_CTRLCLK: length 150
  TOP w0.109: R11.2 153.93,79.95 154.86,79.03 154.86,78.83 R57.1 156.03,78.25 v1(156.11,78.32)
  ART06 w0.087: v1(64.29,98.25) 64.29,99.91 63.5,100.7 63.5,105.36 67.49,109.35 74.22,109.35 76.21,107.36 83.38,107.36 86.01,104.73 120.9,104.73 123.76,107.58 131.83,107.58 133.68,105.73 136.89,105.73 137.9,106.74 142.94,106.74 144.08,105.61 147.88,105.61 150.96,102.53 151.44,102.53 153.31,100.66 153.31,99.11 156.01,96.41 156.01,94.09 156.31,93.79 156.31,91.11 156.46,90.96 156.46,88.61 155.93,88.08 155.93,86.96 157.43,85.45 157.43,84.26 158.94,82.74 158.94,82.15 156.84,80.05 156.84,78.87 156.3,78.32 v1(156.11,78.32)
  BOTTOM w0.109: v1(64.29,98.25) 64.29,96.75 65.56,95.48 65.56,88.98 65.45,88.87 65.18,88.87 65.07,88.76 65.07,88.54 65.18,88.44 65.45,88.44 65.56,88.33 65.56,86.47 65.31,86.22 Q1.2
HDMI_CTRLDATA: length 149.4
  TOP w0.109: v1(156.01,79.02) 155.94,79.09 R49.1 154.54,79.99 154.54,80.42 154.24,80.73 R24.2
  ART06 w0.087: v1(156.01,79.02) 155.98,79.05 155.96,79.05 155.67,78.76 155.67,78.1 155.93,77.84 156.53,77.84 157.32,78.63 157.32,79.86 159.42,81.96 159.42,82.87 158.06,84.23 158.06,85.42 156.4,87.08 156.4,87.95 156.94,88.49 156.94,91.28 156.72,91.5 156.72,94.02 156.42,94.31 156.42,96.62 154,99.05 154,100.88 148.81,106.07 144.17,106.07 143.08,107.16 137.57,107.16 136.58,106.16 133.88,106.16 131.99,108.06 123.57,108.06 120.98,105.46 97.12,105.46 96.15,106.43 85.05,106.43 83.7,107.78 76.37,107.78 74.35,109.8 67.38,109.8 62.86,105.28 62.86,100.57 63.65,99.78 v1(63.65,98.17)
  BOTTOM w0.109: Q2.2 64.6,89.58 65.09,90.07 65.09,95.25 63.65,96.69 v1(63.65,98.17)
HDMI_D0+: length 18.8
  TOP w0.109: FIL7.3 55.46,85.54 R209.1 55.68,86.62 55.68,87.47 54.81,88.35 54.81,88.75 54.67,88.89 D49.6 D49.5 54.67,90.27 54.8,90.4 54.8,93.2 52.63,95.37 52.63,97.87 54.73,99.97 55.26,99.97 55.6,100.31 CN3.7
HDMI_D0-: length 18.6
  TOP w0.109: FIL7.2 56.41,85.51 R209.2 55.9,86.91 55.9,87.56 55.03,88.44 55.03,88.78 55.17,88.93 D49.7 D49.4 55.17,90.27 55.01,90.42 55.01,93.29 52.85,95.46 52.85,97.78 54.82,99.75 55.14,99.75 55.58,99.31 CN3.9
HDMI_D1+: length 20.9
  TOP w0.109: FIL6.3 52.88,86.38 R155.1 53.33,86.82 53.33,88.56 53.19,88.7 D48.4 D48.7 53.19,90.28 53.38,90.47 53.38,93.25 51.51,95.11 51.51,98.46 52.65,99.6 52.65,100.26 54.21,101.81 CN3.4
HDMI_D1-: length 20.8
  TOP w0.109: FIL6.2 53.88,86.41 R155.2 53.55,86.75 53.55,88.56 53.69,88.7 D48.5 D48.6 53.69,90.3 53.6,90.39 53.6,93.34 51.73,95.2 51.73,98.37 52.87,99.51 52.87,100.17 54.3,101.59 55.04,101.59 55.3,101.34 55.3,101.23 55.71,100.81 CN3.6
HDMI_D2+: length 23.3
  TOP w0.109: CN3.1 53.93,103.31 50.7,100.08 50.7,94.19 51.8,93.08 51.8,90.41 51.69,90.3 D48.10 D48.1 51.69,88.7 51.83,88.56 51.83,88.07 51.55,87.79 50.99,87.79 50.75,87.56 50.75,86.78 50.64,86.67 50.64,86.67 50.63,86.67 R113.1 50.39,86.4 FIL5.3
HDMI_D2-: length 23.5
  TOP w0.109: CN3.3 55.52,102.31 55.33,102.5 55.33,102.93 55.17,103.09 54.02,103.09 50.92,99.99 50.92,94.28 52.02,93.18 52.02,90.41 52.19,90.25 D48.9 D48.2 52.19,88.7 52.05,88.56 52.05,87.98 51.64,87.57 51.08,87.57 50.97,87.47 50.97,86.76 R113.2 51.39,86.34 FIL5.2
HDMI_HPD: length 157.5
  TOP w0.076: U1.CV42 v1(179.4,66.29)
  TOP w0.102: v1(66.57,62.23) 66.57,68.49 61.81,73.25 61.81,77.62 62.48,78.3 R446.2 Q14.2 R447.2
  ART06 w0.102: v1(179.4,66.29) 179.4,65.09 178.8,64.49 178.8,64.06 176.97,62.23 176.97,61.21 174.97,59.21 173.22,59.21 171.29,57.28 171.29,56.8 164.57,50.08 155.29,50.08 154.9,50.48 152.38,50.48 151.53,51.33 146.71,51.33 143.02,55.03 139.47,55.03 138.54,55.96 138.54,56.93 133.7,61.78 124.86,61.78 123.66,62.98 122.99,62.98 122.52,62.51 117.78,62.51 116.02,60.75 114.77,60.75 114.28,61.24 113.07,61.24 112.17,60.34 111.38,60.34 109.98,61.74 105.17,61.74 104.04,62.87 93.44,62.87 90.59,60.02 82.03,60.02 79.97,62.08 76.59,62.08 76.01,62.66 73.69,62.66 73.26,63.09 71.82,63.09 71.22,62.5 66.84,62.5 v1(66.57,62.23)
HP_OUT_L: length 9.8
  TOP w0.203: U25.32 26.91,79.65
  TOP w0.305: R425.1 20.94,81.44 20.94,79.74 21.98,78.7 24.26,78.7 25.21,79.65 26.91,79.65
HP_OUT_L_C: length 33.5
  TOP w0.305: D56.N 12.07,102.45 ; 12.07,102.45 J8.3 ; 12.07,102.45 12.07,100.17 11.35,99.45 8.71,99.45 7.57,98.31 7.57,91.11 7.99,90.69 13.68,90.69 15.82,88.55 20.13,88.55 20.83,87.85 20.83,87.48 C499.2 FB35.1
HP_OUT_R: length 10.7
  TOP w0.203: 26.78,79.15 26.89,79.25 U25.33
  TOP w0.305: R423.1 20.4,81.46 20.4,79.46 21.63,78.24 24.56,78.24 25.47,79.15 26.78,79.15
HP_OUT_R_C: length 34
  TOP w0.305: FB34.1 C500.2 20.37,87.31 20.37,87.67 19.98,88.05 15.61,88.05 13.48,90.18 4.41,90.18 3.53,91.06 3.53,94.06 4.79,95.32 4.79,98.53 3.68,99.64 D57.N 2.06,102.39 J8.4
HPD_CONN: length 15.4
  TOP w0.102: CN3.19 59.97,94.31 61.44,92.84 61.44,90.34 R190.1 C232.2 D26.3 61.53,88.13 R447.1 Q14.3
HPOUT-JD: length 56.8
  TOP w0.305: v1(29.86,92.2) 30.02,92.2 30.31,92.49 34.75,92.49 40.4,86.84 R398.1
  BOTTOM w0.305: v1(29.86,92.2) 29.86,92.06 29.39,91.58 29.39,88.21 27.77,86.59 22.26,86.59 21.37,87.47 17.84,87.47 13.52,91.78 12.77,91.78 11.55,93.01 11.55,93.83 10.66,94.72 10.66,97.25 9.29,98.61 9.29,100.66 D53.N 3.92,104.04 3.5,104.45 J8.6
HSON: length 4.9
  BOTTOM w0.109: C422.2 76.75,67.35 75.85,67.35 75.48,67.73 73.62,67.73 73.22,68.13 73.22,68.34 73.12,68.44 U30.18
HSOP: length 4.9
  BOTTOM w0.109: U30.17 73.52,68.47 73.44,68.38 73.44,68.22 73.71,67.95 74.11,67.95 74.22,68.05 74.22,68.15 74.33,68.25 74.55,68.25 74.66,68.15 74.66,68.05 74.77,67.95 75.57,67.95 75.94,67.57 76.75,67.57 C423.2
I2C_CLK1: length 3.4
  BOTTOM w0.102: R126.2 R84.2 57.72,68.54 57.4,68.85 56.77,68.85
  BOTTOM w0.109: 56.77,68.85 U9.115
I2C_CLK2_GPU: length 255
  TOP w0.109: v1(49.97,78.52) 51.35,77.15 53.19,77.15 55.69,74.65 55.69,63.21 56.77,62.12 56.77,58.66 54.81,56.7 53.58,56.7 49.66,52.78 44.5,52.78 v1(44.13,52.41)
  ART03 w0.087: v1(152.94,41.21) 149.74,41.21 144.79,46.16 144.79,51.62 143.82,52.59 140.03,52.59 137.9,50.45 128.51,50.45 126.84,48.79 119.58,48.79 119.09,48.29 99.74,48.29 99.34,47.89 91.49,47.89 91.09,48.29 54.51,48.29 53.4,49.4 45.94,49.4 44.13,51.2 v1(44.13,52.41)
  BOTTOM w0.109: U9.87 50.56,78.06 50.1,78.52 v1(49.97,78.52) 49.45,79.05 49.45,79.86 R88.2 ; CN14.30 228.84,48.2 227.88,47.24 227.88,41.73 226.58,40.42 217.33,40.42 215.83,38.92 209.39,38.92 207.72,40.59 187.96,40.59 186.29,38.92 180.73,38.92 178.48,36.67 178.41,36.59 157.29,36.59 157.17,36.71 155.6,36.71 154.79,37.52 154.79,39.36 v1(152.94,41.21)
I2C_DATA1: length 3.5
  BOTTOM w0.102: 57.34,67.83 57.97,67.83 R86.2 R130.2
  BOTTOM w0.109: U9.116 56.72,68.45 57.34,67.83
I2C_DATA2_GPU: length 255
  TOP w0.109: v1(44.84,52) 44.85,52 49.61,52 53.68,56.07 55.03,56.07 57.3,58.34 57.3,62.55 56.19,63.66 56.19,74.88 53.27,77.8 51.42,77.8 50.79,78.43 v1(50.79,78.52)
  ART03 w0.087: v1(152.94,41.82) 152.24,42.52 149.42,42.52 145.46,46.47 145.46,51.71 144.09,53.09 139.45,53.09 137.35,50.98 128.37,50.98 126.66,49.27 119.38,49.27 118.87,48.76 99.41,48.76 99.02,48.37 91.77,48.37 91.38,48.76 54.86,48.76 53.61,50.01 46.84,50.01 v1(44.84,52)
  BOTTOM w0.109: 50.79,78.57 50.85,78.51 50.88,78.51 50.96,78.43 U9.88 ; 50.79,78.57 v1(50.79,78.52) ; 50.79,78.57 50.71,78.65 50.71,78.68 50.09,79.3 50.09,80 R105.2 ; v1(152.94,41.82) 153.24,41.82 155.28,39.78 155.28,37.72 155.8,37.2 157.38,37.2 157.51,37.08 178.2,37.08 180.53,39.41 185.8,39.41 187.53,41.14 207.87,41.14 209.6,39.41 215.54,39.41 217.06,40.93 226.28,40.93 227.36,42.01 227.36,47.57 228.93,49.15 228.93,49.43 229.04,49.54 229.26,49.54 229.37,49.43 229.37,49.11 229.48,49 229.7,49 229.81,49.11 229.81,49.43 229.92,49.54 230.14,49.54 230.25,49.43 230.25,49.11 230.36,49 CN14.32
IINA: length 69.9
  ART03 w0.305: v1(54.49,10.91) 53.96,10.37 48.87,10.37 48.1,9.59 40.07,9.59 37.57,12.1 37.57,36.41 34.44,39.55 23.56,39.55 19.29,43.82 v1(19.29,44.55)
  BOTTOM w0.203: R219.2 R256.2 R272.2 R271.2
  BOTTOM w0.305: R219.2 19.4,44.65 v1(19.29,44.55)
IINA0: length 2.7
  BOTTOM w0.305: R219.1 22.91,44.65 23.46,45.2 U37.1
IINA1: length 2.5
  BOTTOM w0.305: U37.2 23.22,45.85 23.2,45.83 23.17,45.87 R256.1
IINA2: length 20.6
  ART03 w0.305: v1(23.33,46.98) 24.74,45.57 24.74,43.12 27.48,40.37 v1(32.33,40.37)
  BOTTOM w0.305: v1(32.33,40.37) 33.51,41.55 35.78,41.55 36.35,42.13 R540.1 ; R272.1 23.17,47.14 v1(23.33,46.98) 23.5,47.15 U37.4
IINA3: length 17.8
  ART03 w0.305: v1(36.24,43.6) 35.27,44.57 26.69,44.57 v1(23.47,47.79)
  BOTTOM w0.305: R271.1 22.9,48.37 v1(23.47,47.79) 23.48,47.8 U37.5 ; v1(36.24,43.6) 36.36,43.49 R544.1
IMVP9_VR_READY: length 248.3
  TOP w0.102: v1(49.01,85.67) 48.91,85.58 48.91,84.68 49.23,84.36 49.23,83.64 48.46,82.86 48.46,81.85 49.4,80.91 49.4,78.22 51.95,75.66 53.9,75.66 55.17,74.39 55.17,59.64 v1(55.03,59.5)
  ART03 w0.102: v1(49.01,85.67) 48.61,86.07 48.61,89.29 51,91.68 51,105.86 51.85,106.71 54.21,106.71 56.01,108.51 60.14,108.51 63.22,111.6 75.03,111.6 76.43,110.2 82.76,110.2 84.13,111.57 86.93,111.57 87.87,110.62 101.89,110.62 102.68,111.4 110.76,111.4 111.51,112.15 132.72,112.15 134.19,110.67 137.45,110.67 139.38,112.6 175.99,112.6 177.87,110.72 181.5,110.72 182.11,111.34 183.7,111.34 184.33,110.7 194.69,110.7 197.18,108.22 217.82,108.22 220.91,111.31 223.79,111.31 223.97,111.49 229.07,111.49 230.53,110.02 v1(230.53,107.84)
  BOTTOM w0.102: v1(55.03,59.5) 55.03,59.73 53.36,61.4 U9.3
  BOTTOM w0.203: v1(230.53,107.84) 231.21,107.16 R340.2
INPUT3VSEL: length 5.9
  TOP w0.076: U1.DN49 171.49,61.92 170.96,61.38 169.1,61.38 168.47,60.75 v1(168.4,60.75)
  BOTTOM w0.075: v1(168.4,60.75) 169.02,60.13 R104.2 169,59.91 R107.1
ISETA: length 30.4
  TOP w0.305: CN20.6 CN20.8 27.72,38.28 R565.2 ; CN20.6 CN20.4 ; CN20.6 27.73,40.28 R564.2 ; CN20.4 CN20.2 27.71,44.28 R562.2 27.7,45.14 v1(27.7,45.14) ; CN20.4 27.71,42.28 R563.2
  ART03 w0.305: v1(27.7,45.14) 27.69,45.15 26.87,45.15 24.27,47.76 24.27,49.58 22.56,51.29 v1(20.91,51.29)
  BOTTOM w0.305: 20.92,51.28 v1(20.91,51.29) ; 20.92,51.28 R566.1 21.72,49.82 22.08,49.82 23.45,48.45 U37.6 ; 20.92,51.28 R572.2 R571.1
ISOLATEB: length 4
  BOTTOM w0.127: U30.20 72.32,67.37 72.76,66.93 73.34,66.93 R269.1 R247.1
IST_TP_0: length 1.2
  TOP w0.076: v1(194.51,80.72) 194.56,80.77 194.56,81.01 U1.BF11
  BOTTOM w0.127: v1(194.51,80.72) 194.56,80.77 194.56,81.01 U1.BF11
IST_TP_1: length 1.2
  TOP w0.076: U1.BD11 195.67,80.71 v1(195.66,80.69)
  BOTTOM w0.127: TP13.1 195.26,80.3 v1(195.66,80.69)
IST_TRIG_0: length 1.9
  TOP w0.076: v1(195.1,80.78) 195.05,80.83 195.05,81.51 U1.BE10
  BOTTOM w0.127: U1.BE10 195.1,81.56 v1(195.1,80.78)
IST_TRIG_1: length 2.2
  TOP w0.076: U1.BF10 194.3,81.13 v1(193.9,80.73)
  BOTTOM w0.127: v1(193.9,80.73) 194.25,81.08 194.25,81.62 U1.BF10
ISW: length 2.3
  BOTTOM w0.305: R552.2 32.06,49.71 31.46,49.1 U37.10
KBC_FAN_SPEED: length 250.7
  TOP w0.305: v1(233.15,14.74) 232.86,15.03 231.72,15.03 231.34,15.42 R557.2 232.18,15.88 C640.2 232.77,16.46 232.77,17.21 Q72.3
  ART06 w0.102: v1(41.46,68.88) 41.46,68.53 43.51,66.48 47.14,66.48 48.11,65.5 48.11,60.49 47.39,59.78 47.39,56.75 47.76,56.39 47.76,53 50.14,50.62 82.72,50.62 83.12,50.21 89.5,50.21 90.37,51.08 98.66,51.08 100.77,48.96 129.87,48.96 130.54,48.29 132.8,48.29 arc(135.71,47.69) 138.13,45.98 143.96,40.15 143.96,23.12 147.88,19.2 149.71,19.2 151.36,17.55 151.36,13.88 156.77,8.47 195.93,8.47 196.48,7.92 202.21,7.92 203.27,8.99 206.46,8.99 206.99,8.46 231.15,8.46 233.59,10.9 233.59,14.3 v1(233.15,14.74)
  BOTTOM w0.203: U9.47 41.08,69.25 v1(41.46,68.88)
KBC_FAN_SPEED_GPU: length 262
  ART06 w0.102: v1(231.3,29.65) 231.54,29.41 231.54,20.69 230.68,19.83 230.68,15.85 226.66,11.83 157.01,11.83 154.41,14.43 154.41,17.61 155.46,18.66 155.46,25.2 154.5,26.16 154.5,43.96 152.67,45.79 149.36,45.79 142.3,52.85 138.61,52.85 135.78,55.69 127.96,55.69 125.61,58.04 123.33,58.04 122.65,58.72 121.69,58.72 120.88,57.91 115.07,57.91 114.44,57.28 113.47,57.28 112.93,56.74 107.66,56.74 107.05,57.34 102.88,57.34 101.83,58.39 94.15,58.39 93.38,57.63 76.81,57.63 75.84,58.6 73.03,58.6 72.83,58.39 60.28,58.39 58.62,60.05 52.47,60.05 51.46,61.06 51.46,64.56 49.36,66.66 48.69,66.66 46.68,68.67 45.43,68.67 44.47,69.63 v1(44.47,70.26)
  BOTTOM w0.102: v1(44.47,70.26) 43.86,69.65 U9.48 ; v1(231.3,29.65) 229.4,31.56 229.4,33.77 231.02,35.4 CN14.6
KBC_SPI_HOLD: length 8.5
  BOTTOM w0.102: R560.1 56.71,80.62 57.54,79.79 57.54,78.42 58.5,77.46 60.4,77.46 61.21,76.66
  BOTTOM w0.109: U36.7 61.21,76.66
KBC_WP_SPI: length 6.3
  BOTTOM w0.203: R561.1 66.65,80.51 62.98,80.51 62.48,81.02 U36.3
L_BKLT_EN: length 176.4
  TOP w0.076: U1.DL19 v1(172.21,76.71)
  TOP w0.127: v1(159.61,79.15) 159.48,79.27 R405.1
  ART03 w0.102: v1(172.21,76.71) 171.34,77.59 170.02,77.59 168.93,78.68 166.38,78.68 165.73,78.02 164.56,78.02 163.68,78.9 162.34,78.9 162.09,79.15 v1(159.61,79.15) 159.6,79.13 157.86,79.13 155.33,76.61 148.22,76.61 147.71,77.12 145.18,77.12 144.7,76.64 141.36,76.64 140.81,76.1 140.81,75.01 138.9,73.09 137,73.09 134.4,70.49 127.41,70.49 125.14,68.22 125.14,67.27 122.93,65.06 116.47,65.06 115.44,64.03 101.11,64.03 100.07,62.99 81.83,62.99 81.5,63.33 78.67,63.33 76.92,65.07 76.92,65.07 76.86,65.13 73.46,65.13 73.19,65.4 64.86,65.4 64.34,65.92 63.34,65.92 63.31,65.95 63.31,65.95 62.81,66.44 58.66,66.44 57.59,65.37 52.58,65.37 52.3,65.64 49.04,65.64 48.3,66.38 40.94,66.38 37.97,63.42 v1(37.97,60.74)
  BOTTOM w0.102: U35.2 26.53,52.25 R545.1 R542.1 24.57,53.1 23.72,53.95 23.72,58.51 24.7,59.49 36.72,59.49 v1(37.97,60.74)
L_BRIGHTNESS: length 170.2
  TOP w0.076: v1(166.69,77.14) 167.27,76.55 168.51,76.55 arc(168.55,76.56) 168.59,76.59 168.64,76.64 arc(168.71,76.69) 168.8,76.7 169.41,76.7 U1.DU19
  ART03 w0.102: v1(166.69,77.14) 166.3,77.53 163.4,77.53 163.14,77.79 162.05,77.79 161.89,77.95 159.83,77.95 158.93,77.06 158.26,77.06 156.09,74.88 155.05,74.88 154.63,75.31 147,75.31 146.46,74.77 146.46,74.46 146.06,74.06 143.44,74.06 141.94,72.56 137.26,72.56 134.59,69.88 130.21,69.88 128.66,68.32 127.04,68.32 123.32,64.61 118.29,64.61 117.25,63.57 101.41,63.57 100.3,62.46 81.7,62.46 81.26,62.91 78.39,62.91 76.61,64.68 74.12,64.68 73.8,64.37 65.32,64.37 64.17,65.52 63.14,65.52 62.64,66.03 60.87,66.03 59.73,64.88 59.03,64.88 58.15,64.01 56.43,64.01 55.31,65.13 52.28,65.13 51.98,65.43 48.64,65.43 47.92,66.15 41.23,66.15 38.54,63.46 v1(38.54,63.07)
  ART06 w0.102: v1(38.54,63.07) 38.54,62.83 27.88,52.17 27.88,46.39 27.19,45.7 v1(27.17,45.7)
  BOTTOM w0.102: v1(27.17,45.7) 27.17,45.06 27.47,44.76 R585.1
  BOTTOM w0.305: R530.1 28.97,43.33 R531.1 27.47,43.33 R585.1
L_OUT+: length 4
  TOP w0.508: R265.2 9.55,110.94 C6121.1 9.22,111.28 D60.N 8.29,111.28 CN6.2
L_OUT-: length 4.1
  TOP w0.508: R262.2 10.46,112.69 C6122.1 8.44,112.69 D59.N 8.29,112.53 CN6.1
L_VDD_EN: length 208.2
  TOP w0.076: v1(171.54,75.71) 171.53,75.76 U1.DN21
  ART03 w0.102: v1(171.54,75.71) 171.17,76.08 170.5,76.08 170.22,75.8 169.52,75.8 168.97,76.35 165.4,76.35 165.29,76.46 162.57,76.46 161.59,77.44 160.17,77.44 158.9,76.16 158.22,76.16 156.39,74.33 154.46,74.33 154.34,74.45 152.71,74.45 152.41,74.75 148.96,74.75 147.59,73.38 143.92,73.38 142.52,71.98 137.39,71.98 133.19,67.78 127.21,67.78 123.61,64.18 118.76,64.18 116.95,62.37 108.21,62.37 107.84,62.01 99.36,62.01 98.81,61.46 91.79,61.46 91.29,61.96 81.53,61.96 81.04,62.45 75.78,62.45 74.3,63.93 64.26,63.93 63.39,64.8 61.4,64.8 61.1,65.1 60.54,65.1 59.2,63.76 56.16,63.76 54.99,64.93 52.07,64.93 51.85,65.15 48.45,65.15 47.68,65.92 41.64,65.92 40.15,64.43 40.15,59.94 39.12,58.91 39.12,54.99 41.99,52.11 41.99,49.19 54.57,36.61 54.57,32.56 55.51,31.62 55.51,26.14 57.25,24.39 57.25,16.63 58.84,15.04 58.84,13.59 59.82,12.62 v1(61.27,12.62)
  BOTTOM w0.102: R411.1 61.28,12.63 v1(61.27,12.62) 60.07,12.62 R579.2
LAN_CLK_REQ#: length 108.7
  TOP w0.076: U1.DP34 v1(170.91,69.39)
  TOP w0.102: R12.2 158.82,68.79 v1(159.37,69.33)
  ART03 w0.102: v1(130.9,64.17) 131.16,63.91 135.11,63.91 139.18,67.98 140.12,67.98 140.87,67.24 149.16,67.24 150.78,68.86 154.35,68.86 154.65,69.17 156.27,69.17 156.45,68.98 159.02,68.98 v1(159.37,69.33) 159.59,69.11 162.62,69.11 162.71,69.03 163.98,69.03 164.23,69.28 166.23,69.28 166.65,69.71 170.6,69.71 v1(170.91,69.39)
  ART06 w0.102: v1(130.9,64.17) 130.79,64.06 128.65,64.06 127.83,64.89 118.85,64.89 117.11,66.63 105.98,66.63 105.89,66.72 100.12,66.72 99.52,66.13 86.71,66.13 84.81,64.23 79.4,64.23 76.27,67.36 76.27,70.77 v1(76.18,70.86)
  BOTTOM w0.127: U30.12 76.11,70.93 v1(76.18,70.86)
LAN_CMT: length 1.6
  TOP w0.305: R502.2 70.48,88.49 U31.21
LAN_CMT1: length 1.6
  TOP w0.305: U31.15 76.41,86.89 R504.2
LAN_CT: length 1.6
  TOP w0.305: U31.24 67.51,88.49 R501.2
LAN_CT1: length 1.6
  TOP w0.305: R503.2 73.44,86.89 U31.18
LAN_N1: length 13.2
  TOP w0.305: v1(80.56,89.09) 80.55,89.08 75.94,89.08 75.46,88.6 R504.1 R503.1 73.66,89.21 69.85,89.21 69.52,88.89 R502.1 R501.1
LAN_PCIE_CLK_DN: length 156
  TOP w0.076: U1.CL3 182.38,84.68 182.47,84.58 182.59,84.58 182.68,84.68 182.68,84.98 182.55,85.11 182.29,85.11 182.19,85.21 182.19,85.21 182.12,85.37 182.12,85.73 182.12,85.73 182.12,86.04 182.06,86.24 182.06,86.62 181.67,87.01 181.31,87.01 181.09,87.23 181.09,88.19 181.16,88.27 181.26,88.27 v1(181.5,88.03)
  ART03 w0.075: v1(181.5,88.03) 182.11,88.03 182.32,88.24 182.32,89.82 182.02,90.12 182.02,97.54 182.03,97.55 182.03,97.57
  ART03 w0.087: v1(80.19,76.17) 80.01,75.98 80.01,75.65 80.91,74.74 85.21,74.74 86.31,73.64 99.93,73.64 100.66,74.37 100.66,78.62 106.19,84.14 106.19,90.36 118.45,102.62 128.26,102.62 130.47,100.4 134.23,100.4 134.73,99.9 143.25,99.9 143.81,100.46 148.08,100.46 148.93,101.31 149.85,101.31 150.52,101.98 158.46,101.98 158.61,101.83 161.62,101.83 162.52,101.83 163.05,101.3 164.12,101.3 164.69,100.74 168.19,100.74 168.43,100.97 170.47,100.97 171.16,101.67 173.19,101.67 173.86,101 177.14,101 177.5,100.64 180.34,100.64 182.03,98.95 182.03,97.57
  BOTTOM w0.109: U30.16 74.51,69.33 74.62,69.44 79.73,69.44 80.54,70.24 80.54,75 79.91,75.63 79.91,75.89 v1(80.19,76.17)
LAN_PCIE_CLK_DP: length 156
  TOP w0.076: v1(181.5,88.67) 181.28,88.45 181.09,88.45 180.92,88.28 180.92,87.16 181.24,86.84 181.6,86.84 181.89,86.55 181.89,86.21 181.96,86.01 181.96,85.66 181.96,85.66 181.96,85.34 182.06,85.1 182.11,84.52 U1.CL5
  ART03 w0.075: v1(181.5,88.67) 181.98,88.18 182.05,88.18 182.17,88.31 182.17,88.56 182.1,88.64 182.05,88.64 181.97,88.72 181.97,88.86 182.04,88.94 182.1,88.94 182.17,89.01 182.17,89.17 182.12,89.22 182.04,89.22 181.97,89.29 181.97,89.44 182.05,89.52 182.08,89.52 182.17,89.61 182.17,89.76 181.87,90.06 181.87,97.54 181.85,97.55 181.85,97.57
  ART03 w0.087: v1(79.59,76.17) 79.59,76.02 79.82,75.79 79.82,75.57 80.84,74.56 85.13,74.56 86.23,73.46 100,73.46 100.85,74.3 100.85,78.54 106.37,84.07 106.37,90.29 118.52,102.44 128.18,102.44 130.4,100.22 134.16,100.22 134.66,99.72 143.33,99.72 143.89,100.28 148.15,100.28 149,101.13 149.92,101.13 150.6,101.8 158.38,101.8 158.54,101.65 161.69,101.65 162.44,101.65 162.97,101.12 164.05,101.12 164.59,100.58 168.26,100.58 168.49,100.81 170.54,100.81 171.23,101.5 173.12,101.5 173.81,100.82 177.07,100.82 177.42,100.46 180.26,100.46 181.85,98.87 181.85,97.57
  BOTTOM w0.109: U30.15 74.49,69.73 74.57,69.66 79.64,69.66 80.32,70.33 80.32,74.91 79.69,75.54 79.69,76.07 v1(79.59,76.17)
LAN_PCIE_WAKE#: length 3.2
  BOTTOM w0.102: R351.1 R243.2
  BOTTOM w0.127: U30.21 71.92,66.73 72.23,66.41 R351.1
LAN_PLT_RST#: length 7.5
  BOTTOM w0.102: R358.1 U18.4
  BOTTOM w0.127: R358.1 76.78,65.67 75.27,67.17 73.2,67.17 72.72,67.66 U30.19
LAN_RST: length 166.3
  TOP w0.076: 181.57,52.89 181.57,54.21 181.57,54.21 182.81,55.45 182.81,56.56 185.23,58.97 185.23,61.28 184.76,61.75 184.76,62.65 184.84,62.83 184.84,63.38 U1.CF47
  TOP w0.102: 181.57,52.89 181.57,47.33 177.3,43.05 156.06,43.05 154.89,41.89 154.89,37.92 153.45,36.47 152.32,36.47 151.2,37.59 151.12,37.67 149.25,37.67 147.8,39.12 147.8,47.25 147.36,47.69 147.36,49.25 144.97,51.64 144.97,53.42 144.26,54.13 144.26,58.6 144.94,59.28 146.9,59.28 147.53,59.91 147.53,61.25 148.79,62.51 149.73,62.51 v1(149.79,62.56)
  ART03 w0.102: v1(149.79,62.56) 149.32,63.03 135.97,63.03 134.95,62 130.39,62 128.62,60.23 124.86,60.23 124.51,59.89 122.77,59.89 120.56,57.67 115.32,57.67 114.93,57.27 113.12,57.27 112.66,56.81 107.7,56.81 107.24,57.28 105.6,57.28 104.95,57.93 99.14,57.93 98.92,58.15 81.45,58.15 79.38,60.22 v1(79.19,60.22)
  BOTTOM w0.102: R362.2 78.07,62.44 78.07,62.43 78.52,61.98 78.52,60.89 v1(79.19,60.22)
LAN_TX0N: length 3.8
  TOP w0.097: v1(69.32,87.89) 69.49,87.72 U31.22
  BOTTOM w0.097: v1(69.32,87.89) 69.19,88.02 69.19,89.92 R495.2
LAN_TX0P: length 3.8
  TOP w0.097: U31.23 68.5,87.67 v1(68.72,87.89)
  BOTTOM w0.097: R494.2 68.85,89.92 68.85,88.02 v1(68.72,87.89)
LAN_TX1N: length 16.4
  TOP w0.097: v1(72.27,87.92) 72.46,87.73 U31.19
  BOTTOM w0.097: v1(72.27,87.92) 72.27,87.39 71.83,86.94 67.41,86.94 66.77,87.59 66.77,95.87 FIL16.1
LAN_TX1P: length 15.6
  TOP w0.097: v1(71.67,87.92) 71.47,87.72 U31.20
  BOTTOM w0.097: FIL16.4 67.11,95.87 67.11,87.73 67.55,87.29 69.8,87.29 69.94,87.43 70.18,87.43 70.33,87.29 70.57,87.29 70.71,87.43 70.96,87.43 71.1,87.29 71.69,87.29 71.93,87.53 71.93,87.66 v1(71.67,87.92)
LAN_TX2N: length 10.3
  TOP w0.097: U31.16 75.43,87.7 v1(75.25,87.88)
  BOTTOM w0.097: R499.2 73.86,95.91 73.86,93.24 75.12,91.98 75.12,88.01 v1(75.25,87.88)
LAN_TX2P: length 10.3
  TOP w0.097: v1(74.65,87.88) 74.44,87.68 U31.17
  BOTTOM w0.097: R498.2 73.52,95.88 73.52,93.09 74.78,91.83 74.78,88.01 v1(74.65,87.88)
LAN_TX3N: length 19.3
  TOP w0.097: v1(78.23,87.95) 78.4,87.78 U31.13
  BOTTOM w0.097: R505.2 75.24,102.17 76.95,102.17 79.33,99.79 79.33,90.23 78.1,89 78.1,88.08 v1(78.23,87.95)
LAN_TX3P: length 18.7
  TOP w0.097: v1(77.63,87.95) 77.41,87.73 U31.14
  BOTTOM w0.097: v1(77.63,87.95) 77.76,88.07 77.76,89.14 78.99,90.37 78.99,99.65 76.81,101.82 75.24,101.82 R500.2
LAN_VDDEN: length 54.9
  ART06 w0.102: v1(73.29,62.29) 73.06,62.06 71.75,62.06 71.41,61.72 61.25,61.72 59.7,63.27 56.46,63.27 55.26,64.46 55.26,71.62 54.42,72.46 51.86,72.46 51.55,72.16 49.38,72.16 49.06,71.83 47.15,71.83 45.67,73.32 45.67,74.16 44.48,75.35 44.48,77.43 43.5,78.41 43.5,79.18 45.49,81.17 45.49,81.67 46.22,82.4 46.95,82.4 v1(48.66,84.11)
  BOTTOM w0.102: v1(48.66,84.11) 49.07,83.71 R1399.2
  BOTTOM w0.305: v1(73.29,62.29) 73.24,62.29 R198.2 72.18,62.16 U4.3
LAO1_CLKN: length 21
  TOP w0.109: CN21.8 36.55,25.73 36.16,25.34 34.83,25.34 v1(34.64,25.53)
  BOTTOM w0.109: U42.35 48.5,25.18 48.4,25.09 38.09,25.09 37.98,25.2 37.98,25.66 37.75,25.9 37.36,25.9 37.11,25.65 37.11,24.74 37.03,24.66 36.73,24.66 36.67,24.72 36.67,25.74 36.42,25.99 36.02,25.99 35.8,25.76 35.8,25.08 35.73,25.01 35.48,25.01 35.15,25.34 34.83,25.34 v1(34.64,25.53)
LAO1_CLKP: length 21
  TOP w0.109: v1(34.64,24.93) 34.83,25.12 36.17,25.12 36.56,24.73 CN21.9
  BOTTOM w0.109: v1(34.64,24.93) 34.83,25.12 35.06,25.12 35.39,24.79 35.82,24.79 36.01,24.99 36.01,25.67 36.11,25.77 36.33,25.77 36.45,25.65 36.45,24.63 36.64,24.44 37.12,24.44 37.33,24.65 37.33,25.56 37.45,25.68 37.66,25.68 37.77,25.57 37.77,25.11 38,24.87 48.42,24.87 48.51,24.78 U42.34
LAO1_DATAN0: length 21
  TOP w0.109: CN21.24 43.91,16.73 44.06,16.58 44.06,16.11 44.21,15.95 44.88,15.95 45.06,16.12 45.06,16.55 44.95,16.66 44.56,16.66 44.45,16.77 44.45,16.99 44.56,17.1 44.95,17.1 45.06,17.21 45.06,17.87 48.25,21.07 48.25,23.11 49.38,24.23 49.38,28.64 49.07,28.94 48.36,28.94 48.2,28.78 48.2,28.54 v1(48.34,28.4)
  BOTTOM w0.109: U42.42 48.59,27.98 48.52,27.91 48.28,27.91 48.21,27.98 48.21,28.27 v1(48.34,28.4)
LAO1_DATAN1: length 21
  TOP w0.109: CN21.2 36.49,31.73 36.11,31.35 35.18,31.35 v1(34.98,31.55)
  BOTTOM w0.109: v1(34.98,31.55) 35.17,31.35 36.99,31.35 37.76,30.59 37.92,30.59 38.28,30.96 38.59,30.96 38.88,30.67 38.88,30.31 38.53,29.97 38.53,29.81 38.68,29.66 38.84,29.66 39.21,30.03 39.55,30.03 39.83,29.75 39.83,29.41 39.46,29.04 39.46,28.88 40.94,27.4 44.64,27.4 44.93,27.11 48.4,27.11 48.48,27.18 U42.40
LAO1_DATAN2: length 21
  TOP w0.109: v1(34.26,28.55) 34.46,28.36 36.12,28.36 36.49,28.73 CN21.5
  BOTTOM w0.109: v1(34.26,28.55) 34.46,28.35 36.6,28.35 36.69,28.45 36.69,29.27 36.92,29.5 37.37,29.5 37.57,29.3 37.57,28.45 37.67,28.35 38.34,28.35 40.8,25.89 48.37,25.89 48.47,25.98 U42.37
LAO1_DATAN3: length 21
  TOP w0.109: v1(34.71,23.46) 34.88,23.29 36.13,23.29 36.57,23.73 CN21.10
  BOTTOM w0.109: v1(34.71,23.46) 34.87,23.3 37.41,23.3 37.52,23.41 37.52,23.73 37.78,24 38.15,24 38.39,23.76 38.39,23.42 38.54,23.27 38.69,23.27 38.83,23.41 38.83,23.7 39.07,23.94 39.47,23.94 39.7,23.7 39.7,23.41 39.81,23.3 40.03,23.3 40.14,23.41 40.14,23.7 40.38,23.94 40.78,23.94 41.02,23.7 41.02,23.52 41.14,23.4 41.35,23.4 41.46,23.5 41.46,23.81 41.67,24.03 42.11,24.03 42.33,23.81 42.33,23.41 42.44,23.3 47.55,23.3 48.15,23.89 48.45,23.89 48.53,23.98 U42.32
LAO1_DATAP0: length 21
  TOP w0.109: CN21.23 44.97,15.73 45.27,16.03 45.27,17.78 48.47,20.98 48.47,23.02 49.6,24.14 49.6,28.73 49.16,29.16 48.27,29.16 47.98,28.87 47.98,28.63 v1(47.74,28.4)
  BOTTOM w0.109: v1(47.74,28.4) 47.99,28.14 47.99,27.89 48.19,27.69 48.51,27.69 48.62,27.58 U42.41
LAO1_DATAP1: length 21
  TOP w0.109: v1(34.98,30.95) 35.15,31.13 36.12,31.13 36.51,30.73 CN21.3
  BOTTOM w0.109: v1(34.98,30.95) 35.16,31.13 36.9,31.13 37.66,30.37 38.01,30.37 38.37,30.74 38.5,30.74 38.66,30.58 38.66,30.4 38.31,30.06 38.31,29.72 38.59,29.44 38.93,29.44 39.3,29.81 39.45,29.81 39.61,29.66 39.61,29.5 39.24,29.13 39.24,28.79 40.85,27.18 44.55,27.18 44.84,26.89 48.38,26.89 48.49,26.78 U42.39
LAO1_DATAP2: length 21
  TOP w0.109: v1(34.26,27.95) 34.45,28.14 36.08,28.14 36.49,27.73 CN21.6
  BOTTOM w0.109: U42.36 48.49,25.58 48.4,25.67 48.38,25.67 48.37,25.67 40.71,25.67 38.25,28.13 37.58,28.13 37.35,28.36 37.35,29.21 37.28,29.28 37.02,29.28 36.91,29.18 36.91,28.36 36.69,28.13 34.44,28.13 v1(34.26,27.95)
LAO1_DATAP3: length 21
  TOP w0.109: CN21.11 36.5,22.73 36.17,23.07 34.92,23.07 v1(34.71,22.86)
  BOTTOM w0.109: U42.31 48.54,23.58 48.45,23.68 48.24,23.68 47.64,23.08 42.35,23.08 42.11,23.32 42.11,23.72 42.02,23.81 41.77,23.81 41.67,23.72 41.67,23.41 41.44,23.18 41.04,23.18 40.8,23.42 40.8,23.61 40.69,23.72 40.47,23.72 40.36,23.61 40.36,23.32 40.12,23.08 39.72,23.08 39.49,23.32 39.49,23.61 39.38,23.72 39.16,23.72 39.05,23.61 39.05,23.32 38.78,23.05 38.45,23.05 38.17,23.33 38.17,23.67 38.06,23.78 37.87,23.78 37.73,23.64 37.73,23.32 37.5,23.08 34.93,23.08 v1(34.71,22.86)
LAO_CLKN: length 22.1
  TOP w0.109: CN21.30 45.33,22.73 45.59,22.99 45.59,23.86 45.54,23.91 45.07,23.91 44.78,24.2 44.78,24.51 45.06,24.79 45.54,24.79 45.59,24.85 45.59,31.75 46.02,32.18 46.48,32.18 v1(46.66,32.35)
  BOTTOM w0.109: v1(46.66,32.35) 46.83,32.18 48.26,32.18 48.64,32.55 50.38,32.55 51.26,31.68 51.26,29.34 51.33,29.26 U42.47
LAO_CLKP: length 22.1
  TOP w0.109: v1(46.66,31.75) 46.45,31.96 46.11,31.96 45.81,31.66 45.81,24.75 45.63,24.57 45.15,24.57 45,24.42 45,24.29 45.16,24.13 45.63,24.13 45.81,23.95 45.81,22.9 45.42,22.51 44.58,22.51 43.8,21.73 CN21.29
  BOTTOM w0.109: v1(46.66,31.75) 46.87,31.96 48.35,31.96 48.73,32.33 50.29,32.33 51.04,31.59 51.04,29.37 50.93,29.26 U42.46
LAO_DATAN0: length 22.1
  TOP w0.109: v1(41.15,31.55) 42.11,31.55 42.29,31.73 CN21.39
  BOTTOM w0.109: v1(41.15,31.55) 41.4,31.31 41.61,31.31 45.43,35.14 52.57,35.14 54.13,33.58 54.13,29.35 54.13,29.35 U42.54
LAO_DATAN1: length 22.1
  TOP w0.109: v1(41.32,28.54) 42.1,28.54 42.29,28.73 CN21.36
  BOTTOM w0.109: U42.52 53.33,29.26 53.23,29.36 53.23,32.81 51.77,34.27 46.41,34.27 43.07,30.93 43.07,28.91 42.56,28.4 41.46,28.4 v1(41.32,28.54)
LAO_DATAN2: length 22.1
  TOP w0.109: v1(47.44,33.47) 47.2,33.23 46.2,33.23 46.09,33.34 46.09,33.92 45.76,34.25 45.25,34.25 44.88,33.87 44.88,25.99 44.62,25.73 CN21.33
  BOTTOM w0.109: v1(47.44,33.47) 47.6,33.32 51.07,33.32 52.01,32.38 52.01,29.38 52.13,29.25 U42.49
LAO_DATAN3: length 22.1
  TOP w0.109: CN21.27 45.32,19.73 46.85,21.26 46.85,24.81 47.09,25.05 47.89,25.05 47.96,25.13 47.96,25.39 47.86,25.49 47.09,25.49 46.85,25.73 46.85,26.87 47.09,27.11 48.32,27.11 48.42,27.21 48.42,27.43 48.31,27.55 47.09,27.55 46.85,27.79 46.85,29.69 47.18,30.02 47.48,30.02 v1(47.69,30.22)
  BOTTOM w0.109: v1(47.69,30.22) 47.83,30.08 49.72,30.08 50.05,29.75 50.05,29.35 50.13,29.26 U42.44
LAO_DATAP0: length 22.1
  TOP w0.109: v1(41.15,30.95) 41.54,31.34 41.78,31.34 42.38,30.73 CN21.38
  BOTTOM w0.109: v1(41.15,30.95) 41.29,31.09 41.7,31.09 45.53,34.92 52.47,34.92 53.91,33.49 53.91,29.48 53.73,29.31 U42.53
LAO_DATAP1: length 22.1
  TOP w0.109: v1(41.32,27.94) 41.7,28.32 41.89,28.32 42.48,27.73 CN21.35
  BOTTOM w0.109: U42.51 52.93,29.26 53.02,29.35 53.02,32.72 51.68,34.05 46.51,34.05 43.28,30.83 43.28,28.82 42.65,28.18 41.56,28.18 v1(41.32,27.94)
LAO_DATAP2: length 22.1
  TOP w0.109: CN21.32 44.06,24.73 44.26,24.93 44.26,25.06 45.1,25.9 45.1,33.78 45.34,34.03 45.67,34.03 45.88,33.82 45.88,33.25 46.11,33.01 47.3,33.01 v1(47.44,32.87)
  BOTTOM w0.109: v1(47.44,32.87) 47.67,33.1 50.98,33.1 51.79,32.29 51.79,29.29 51.73,29.23 U42.48
LAO_DATAP3: length 22.1
  TOP w0.109: CN21.26 43.91,18.73 44.69,19.51 45.41,19.51 47.07,21.17 47.07,24.72 47.18,24.84 47.98,24.84 48.18,25.04 48.18,25.48 47.95,25.71 47.18,25.71 47.07,25.82 47.07,26.78 47.18,26.89 48.41,26.89 48.64,27.12 48.64,27.52 48.4,27.77 47.18,27.77 47.07,27.88 47.07,29.6 47.27,29.8 47.5,29.8 v1(47.69,29.62)
  BOTTOM w0.109: U42.43 49.73,29.26 49.83,29.36 49.83,29.66 49.63,29.86 47.93,29.86 v1(47.69,29.62)
LCD_BA<1>: length 82.6
  TOP w0.102: v1(35.48,17.6) 35.61,17.73 CN21.16
  ART06 w0.102: v1(35.48,17.6) 35.95,17.13 35.95,16.67 35.72,16.43 34.49,16.43 32.59,18.32 32.59,25.45 22.96,35.08 22.96,44.65 21.91,45.7 21.91,49.39 23.34,50.82 24.41,50.82 37.65,64.07 38.98,64.07 40.05,65.13 40.05,73.13 41.29,74.36 v1(41.29,75.77)
  BOTTOM w0.102: U9.68 42.96,75.87 42.73,75.64 41.43,75.64 v1(41.29,75.77)
  BOTTOM w0.203: v1(35.48,17.6) 35.41,17.53 R933.1
LCD_BA<2>: length 79.8
  TOP w0.102: v1(35.47,16.83) 35.58,16.73 CN21.17
  ART06 w0.102: v1(41.32,73.16) 40.98,73.16 40.32,72.5 40.32,65.03 39.09,63.8 37.76,63.8 24.52,50.56 23.45,50.56 22.17,49.28 22.17,45.81 23.22,44.76 23.22,35.19 32.86,25.56 32.86,18.47 34.49,16.83 v1(35.47,16.83)
  BOTTOM w0.102: v1(41.32,73.16) 41.34,73.16 43.76,75.59 U9.70
  BOTTOM w0.203: v1(35.47,16.83) 35.35,16.71 R934.1
LCD_BA<GND>: length 1.6
  TOP w0.102: CN21.18 36.25,15.73 v1(36.18,15.8)
  BOTTOM w0.102: PR120.1 36.13,15.75 v1(36.18,15.8)
LCD_VCC:
  vias: v1(55.04,15.19) v1(55.03,14.73) v1(55.08,15.67) v1(55.55,15.62) v2(38.5,20.72) v2(38.56,19.81) v2(38.53,18.77)
LDO2-CAP: length 4.2
  TOP w0.203: 28.19,75.89 29.19,76.9 U25.39
  TOP w0.305: 28.19,75.89 27.19,75.89 26.34,75.04 C472.2
LDR: length 2.3
  BOTTOM w0.305: R547.1 32.1,48.87 31.68,48.45 U37.11
LED0: length 4.5
  BOTTOM w0.102: U30.27 67.61,70.13 67.47,70 66.74,70 TP41.1
LED1: length 1.2
  BOTTOM w0.102: U30.26 69.24,69.73 TP40.1
LED2: length 3.3
  BOTTOM w0.102: TP39.1 67.3,69.02 69.2,69.02 69.52,69.33 U30.25
LED_EN: length 6.3
  BOTTOM w0.102: 32.17,52.89 32.17,52.89 R14.1 31.69,52.89 29.67,52.89 U35.4
  BOTTOM w0.114: 32.17,52.89 R546.2 R554.1 33.58,52.88 R553.1
LED_ON: length 40.4
  ART03 w0.102: v1(31.89,54.43) 31.91,54.45 31.91,57.84 40.74,66.68 50.31,66.68 v1(50.88,66.11)
  BOTTOM w0.102: v1(50.88,66.11) 50.89,66.11 52.29,67.51 52.41,67.51 53.1,68.2 53.1,68.79 52.39,69.5 52.39,70.61 53.8,72.01 53.8,76.2 53.36,76.64 U9.94 ; v1(31.89,54.43) 31.69,54.23 R14.2
LGATE1: length 53
  TOP w0.508: PR16.1 189.35,113.27 v2(189.35,106.86)
  ART06 w0.508: v2(228.17,103.2) 226.82,103.2 225.96,102.35 225.96,101.19 225.47,100.7 220.8,100.7 220.28,100.18 210.31,100.18 209.8,99.68 199.04,99.68 191.86,106.86 v2(189.35,106.86)
  BOTTOM w0.203: v2(228.17,103.2) 227.96,102.99 U3.35
LGATE2: length 63.7
  TOP w0.508: v2(183.39,114.19) 183.31,114.11 PR48.1
  ART06 w0.508: v2(228.19,101.93) 228.19,101.98 228.14,102.04 227.4,102.04 226.95,101.59 226.95,100.79 225.93,99.77 221.35,99.77 220.66,99.08 218.25,99.08 217.11,97.94 192.52,97.94 189.99,100.47 185.06,100.47 184.44,101.1 184.44,111.42 183.39,112.47 v2(183.39,114.19)
  BOTTOM w0.203: v2(228.19,101.93) 227.94,102.19 U3.37
LGATE3: length 25.6
  TOP w0.508: v2(211.92,113.67) 212.63,114.38 PR74.1
  BOTTOM w0.305: PU3.7 203.7,104.75 203.39,104.44
  BOTTOM w0.508: v2(211.92,113.67) 211.96,113.64 211.96,107.85 212.68,107.13 212.68,103.11 211.54,101.96 208.93,101.96 208.13,101.16 205.64,101.16 203.39,103.42 203.39,104.44
LINE1_L: length 3.1
  TOP w0.203: U25.22 29.19,83.91 28.86,84.24
  TOP w0.305: C471.1 28.86,85.48 28.86,84.24
LINE1_R: length 3.2
  TOP w0.203: 29.59,83.86 U25.21
  TOP w0.305: 29.59,83.86 29.59,84.97 C470.1
LINE1L-VREFO: length 4.4
  TOP w0.203: U25.31 24.86,80.05 24.1,79.28 R391.2
LINE1R-VREFO: length 4.2
  TOP w0.203: U25.30 24.64,80.45 24.25,80.05 R392.2
LINE2_L: length 3.4
  TOP w0.203: U25.24 28.39,83.37 27.72,84.04
  TOP w0.305: C378.1 27.6,85.21 27.6,84.16 27.72,84.04
LINE2_R: length 3.1
  TOP w0.203: 28.79,83.55 U25.23
  TOP w0.305: C376.1 28.11,84.24 28.79,83.55
LTB_CFG0_N: length 16.8
  TOP w0.075: v1(194.06,88) 193.94,88 193.16,88.77 R106.2
  TOP w0.076: v1(204.36,83.65) 204.15,83.44 U1.AG6
  ART03 w0.075: v1(204.36,83.65) 203.91,84.09 203.91,85.12 203.72,85.31 201.41,85.31 201.31,85.41 199.97,85.41 199.2,86.18 199.2,87.04 198.08,88.16 194.22,88.16 v1(194.06,88)
  BOTTOM w0.127: R114.1 205.08,84.52 TP9.1 204.36,83.65 v1(204.36,83.65)
LTB_CFG1_N: length 13.2
  TOP w0.075: v1(199.75,87.37) 199.06,88.05 199.06,88.28 198.78,88.56 197.61,88.56 197.34,88.84 R146.2
  TOP w0.076: U1.AE7 205.18,82.43 v1(205.28,82.43)
  ART03 w0.075: v1(205.28,82.43) 204.89,82.82 204.89,83.86 204.24,84.52 204.24,85.27 203.88,85.63 201.52,85.63 201.43,85.71 200.4,85.71 199.75,86.36 v1(199.75,87.37)
LTB_CFG2_N: length 0.5
  TOP w0.076: U1.AG7 v1(204.36,83.01)
LTB_CFG3_N: length 13.8
  TOP w0.075: R148.1 R147.2 198.93,88.74 v1(199.73,87.93)
  TOP w0.076: U1.AD9 v1(206.19,82.4)
  ART03 w0.075: v1(199.73,87.93) 200.18,87.48 200.18,87.24 200.09,87.15 200.09,86.31 200.54,85.86 201.5,85.86 201.58,85.78 203.94,85.78 204.39,85.33 204.39,84.63 204.92,84.1 205.49,84.1 205.73,83.86 205.73,82.73 206.06,82.4 v1(206.19,82.4)
  BOTTOM w0.127: v1(206.19,82.4) 206.18,82.39 TP15.1
LTB_CFG4_N: length 17.6
  TOP w0.075: v1(194.08,88.58) R149.2 R159.1
  TOP w0.076: v1(205.14,81.79) 205.14,81.82 U1.AE9
  ART03 w0.075: v1(205.14,81.79) 204.74,82.19 204.74,83.76 204.71,83.79 204.71,83.79 204.08,84.42 204.08,85.17 203.79,85.46 201.47,85.46 201.37,85.56 200.2,85.56 199.42,86.35 199.42,87.1 197.93,88.58 v1(194.08,88.58)
LTB_CFG5_N: length 0.5
  TOP w0.076: U1.AB9 v1(207.1,82.4)
LTB_CFG6_N: length 0.5
  TOP w0.076: v1(203.44,83.67) 203.21,83.44 U1.AJ6
LTB_CFG7_N: length 0.5
  TOP w0.076: U1.AB7 v1(207.1,83.03)
LTB_CFG8_N: length 27.3
  TOP w0.075: R169.2 191.58,88.65 v1(193.08,87.15)
  TOP w0.076: U1.V10 v1(208.93,81.76)
  ART03 w0.075: v1(193.08,87.15) 193.13,87.15 194.21,86.07 195.22,86.07 195.73,85.57 195.73,82.12 196.36,81.49 198.52,81.49 198.81,81.2 204.93,81.2 205.67,80.46 207.44,80.46 208.75,81.76 v1(208.93,81.76)
  BOTTOM w0.075: v1(208.93,81.76) 209.36,81.34 209.36,80.86 209.6,80.61 210.41,80.61 R178.1
  BOTTOM w0.127: v1(208.93,81.76) 208.72,81.76 TP29.1
LTB_CFG9_N: length 16.5
  TOP w0.075: R250.2 196.62,89.07 196.62,87.68 197.09,87.2 v1(197.15,87.2)
  TOP w0.076: U1.AJ5 203.23,84.09 v1(203.44,84.3)
  ART03 w0.075: v1(197.15,87.2) 197.2,87.15 197.33,87.15 199.37,85.11 199.37,82.22 199.92,81.66 202.3,81.66 203.07,82.43 203.07,84.08 203.29,84.3 v1(203.44,84.3)
  BOTTOM w0.127: v1(203.44,84.3) 203.39,84.36 ; 203.39,84.36 203.92,84.36 R270.1 ; 203.39,84.36 TP30.1
LTB_CFG10_N: length 19.1
  TOP w0.075: R283.2 v1(199.69,88.6)
  TOP w0.076: U1.Y10 v1(208.02,81.76)
  ART03 w0.075: v1(208.02,81.76) 207.69,81.76 207.53,81.92 207.53,84.77 207.15,85.16 205.33,85.16 204.17,86.31 202.58,86.31 200.95,87.94 200.95,89.76 200.51,90.2 200.08,90.2 199.69,89.81 v1(199.69,88.6)
  BOTTOM w0.127: R332.1 207.69,80.63 207.69,81.67 TP31.1 207.84,81.76 v1(208.02,81.76)
LTB_CFG11_N: length 3.4
  TOP w0.076: U1.AJ7 v1(203.44,83.01)
  BOTTOM w0.127: R333.1 202.56,81.32 202.94,81.71 202.94,82.51 v1(203.44,83.01)
LTB_CFG12_N: length 24
  TOP w0.075: R336.2 192.35,88.44 193.94,86.85 v1(194.15,86.85)
  TOP w0.076: U1.AB10 v1(207.1,81.76)
  ART03 w0.075: v1(207.1,81.76) 206.67,81.33 206.67,80.9 206.53,80.75 205.83,80.75 205.16,81.42 199.26,81.42 198.36,82.32 198.36,85.46 196.87,86.95 194.25,86.95 v1(194.15,86.85)
  BOTTOM w0.127: TP33.1 206.66,81.52 206.66,81.01 206.4,80.76 205.6,80.76 R341.1
LTB_CFG13_N: length 18.8
  TOP w0.075: R343.2 195.8,88.63 194.59,87.43 v1(194.11,87.43)
  TOP w0.076: v1(202.53,82.56) U1.AL7
  ART03 w0.075: v1(194.11,87.43) 194.75,87.43 195.08,87.75 198.25,87.75 199,87 199,85.98 200.22,84.77 200.22,82.35 200.63,81.93 201.91,81.93 v1(202.53,82.56)
  BOTTOM w0.127: R366.1 201.72,80.82 202.38,81.48 TP34.1 202.38,82.4 v1(202.53,82.56)
LTB_CFG14_N: length 2.8
  TOP w0.076: U1.AL9 201.91,82.14 v1(201.63,82.41)
  BOTTOM w0.127: v1(201.63,82.41) 201.63,81.64 TP42.1 200.94,80.95 R367.1
LTB_CFG15_N: length 2.4
  TOP w0.076: U1.AJ9 v1(203.44,82.36)
  BOTTOM w0.127: v1(203.44,82.36) 203.41,82.33 TP43.1 203.32,81.24 R376.1
LTB_CFG_STB0_DN: length 1
  TOP w0.076: U1.V6 v1(208.93,83.68)
  BOTTOM w0.127: TP44.1 209.18,83.92 v1(208.93,83.68)
LTB_CFG_STB0_DP: length 0.8
  TOP w0.076: U1.V7 v1(208.93,83.03)
  BOTTOM w0.127: v1(208.93,83.03) 208.91,83 TP45.1
LTB_CFG_STB1_DN: length 0.5
  TOP w0.076: U1.Y6 v1(208.04,83.7)
LTB_CPU_JTAG_TCLK: length 7
  TOP w0.076: U1.P3 210.57,85.28 210.57,87.33 210.38,87.53 209.95,87.53 v1(209.56,87.14)
  BOTTOM w0.102: R878.2 207.35,87.41 207.62,87.14 v1(209.56,87.14)
LTB_CPU_JTAG_TDI: length 9.3
  TOP w0.076: U1.K5 212.5,84.32 212.5,84.5 212.69,84.69 212.69,84.88 212.59,84.98 212.59,85.23 212.62,85.26 212.62,85.26 212.87,85.51 212.87,86.71 212.88,86.72 213.4,87.25 213.42,87.27 214.83,87.27 v1(215.31,87.75) 215.36,87.8 215.36,89.95 R133.1
  BOTTOM w0.102: v1(215.31,87.75) 215.31,87.96 215.66,88.31 R880.2
LTB_CPU_JTAG_TDO: length 5.3
  TOP w0.075: R131.1 213.53,88.08 213.32,88.08 v1(213.28,88.05) 212.42,87.19 212.42,87.06
  TOP w0.076: U1.K3 212.01,85.14 212.01,85.77 211.93,85.94 211.93,86.34 212.39,86.79 212.39,87.02 212.42,87.06
  BOTTOM w0.102: R883.2 213.22,88.11 v1(213.28,88.05)
LTB_CPU_JTAG_TMS: length 5.2
  TOP w0.076: v1(210.2,87.16) 210.2,87.14 210.37,86.96 210.37,85.55 210.1,85.28 210.1,84.99 210.16,84.93 210.43,84.66 U1.P4
  BOTTOM w0.102: R886.2 209.92,87.44 v1(210.2,87.16) 210.53,87.16 210.88,86.81 R132.1
LTB_CPU_JTAG_TRST_N: length 3.2
  TOP w0.075: 211.21,88.08 210.94,87.81 210.94,86.17 U1.N1
  TOP w0.102: 211.21,88.08 R890.2
LTB_OVERRIDE: length 8.3
  BOTTOM w0.203: D66.P 146.82,92.89 146.28,92.35 144.16,92.35 143.96,92.15 Q88.3 143.96,91.77 R860.2 146.74,89 D68.P
LTB_PCH_JTAG_TCLK: length 3.3
  TOP w0.076: v1(210.33,83.97) 210.31,83.97 210.12,84.16 U1.R5
  BOTTOM w0.102: v1(210.33,83.97) 210.33,84.29 R135.1 210.03,84.59 208.73,84.59 R893.2
LTB_PCH_JTAG_TDI: length 4.9
  TOP w0.075: v1(214.59,87.68) 214.79,87.88 R137.1
  TOP w0.076: v1(214.59,87.68) 214.34,87.43 213.34,87.43 212.7,86.79 212.7,86.47 U1.K1
  BOTTOM w0.102: v1(214.59,87.68) 214.59,87.81 214.84,88.06 R881.2
LTB_PCH_JTAG_TDO: length 7.2
  TOP w0.075: 212.54,86.88 213.32,87.67 213.7,87.67 213.82,87.79 v1(213.97,87.79) 214.13,87.79 214.39,88.05 214.39,90.12 R141.1
  TOP w0.076: U1.K2 212.35,85.5 212.17,85.67 212.17,85.81 212.09,85.98 212.09,86.28 212.54,86.73 212.54,86.88
  BOTTOM w0.102: R884.2 214.04,88.01 213.97,87.95 v1(213.97,87.79)
LTB_PCH_JTAG_TMS: length 4.8
  TOP w0.076: U1.N3 211.38,85.19 211.38,85.86 211.46,85.98 211.46,87.04 v1(211.5,87.09)
  BOTTOM w0.102: R887.2 210.7,87.46 211.07,87.09 v1(211.5,87.09) 211.54,87.09 211.66,86.96 R889.1
LTB_PCH_JTAG_TRST_N: length 5.3
  TOP w0.076: U1.N5 211,84.29 210.71,84.58 210.71,84.93 210.73,84.96 210.73,87.39
  TOP w0.102: 210.73,87.39 210.73,88.06 211.31,88.63 211.73,88.63
LTB_PCH_JTAGX: length 5.3
  TOP w0.075: v1(211.48,87.7) 211.21,87.7 211.13,87.62 211.13,86.52 211.26,86.4 211.26,85.96 211,85.7 U1.N2
  BOTTOM w0.102: R879.2 210.91,89.87 211.48,89.31 v1(211.48,87.7)
M.2_BT_PCMCLK: length 80.3
  TOP w0.102: CN22.8 131.35,106.86 130.63,107.58 127.48,107.58 124.55,104.65 v1(124.55,104.44) ; v1(145.63,58.52) 145.07,57.95 145.07,54.5 145.63,53.94 145.63,51.61 147.15,50.09 R414.1
  ART06 w0.102: v1(124.55,104.44) 124.55,104.38 123.48,103.32 123.48,92.06 135.53,80.02 135.53,69.18 135.56,69.15 135.56,69.08 138.49,66.14 139.96,66.14 143.89,62.21 143.89,60.91 145.63,59.17 v1(145.63,58.52)
M.2_BT_PCMFRM_CRF_RST_N: length 77.5
  TOP w0.102: v1(125.14,104.54) 125.14,104.62 127.39,106.87 R443.1 R415.1 130.6,106.87 131.1,106.36 CN22.10 ; R214.1 149.29,50.37 147.17,50.37 145.95,51.6 145.95,54.51 145.35,55.11 145.35,57.4 v1(146.04,58.09)
  ART06 w0.102: v1(125.14,104.54) 125.08,104.48 125.08,104.31 123.69,102.91 123.69,92.24 135.73,80.19 135.73,69.26 138.63,66.37 140.02,66.37 144.13,62.26 144.13,61.01 146.04,59.1 v1(146.04,58.09)
M.2_BT_PCMIN: length 75.7
  TOP w0.102: CN22.12 131.31,105.86 130.38,104.94 126.88,104.94 126.51,104.56 v1(126.51,104.49) ; 147.01,58.51 147.01,58 146.01,57 146.01,55.38 146.57,54.83 146.57,51.6 147.24,50.93 148.74,50.93 149.26,51.45 R416.1 ; 147.01,58.51 v1(147.07,58.57) 147.01,58.57 147.01,58.51
  ART06 w0.102: v1(126.51,104.49) 126.47,104.45 126.24,104.45 124.16,102.38 124.16,92.56 137.78,78.94 137.78,67.89 138.87,66.8 140.17,66.8 144.67,62.29 144.67,61.16 147.07,58.76 v1(147.07,58.57)
M.2_BT_PCMOUT_CLKREQ0: length 78.3
  TOP w0.102: v1(125.7,104.52) 125.7,104.37 126.15,103.92 129.11,103.92 R213.2 129.62,104.43 130.42,104.43 131.35,105.36 CN22.14 ; v1(146.5,58.5) 146.52,58.49 146.52,57.99 145.67,57.14 145.67,55.32 146.34,54.65 146.34,51.5 147.17,50.67 148.77,50.67 149.1,51 R417.1
  ART06 w0.102: v1(125.7,104.52) 125.7,104.42 123.89,102.61 123.89,92.4 135.93,80.36 135.93,69.45 138.79,66.59 140.08,66.59 144.39,62.28 144.39,61.08 146.5,58.97 v1(146.5,58.5)
M_0_CSA1_N: length 81.9
  TOP w0.135: CN11.162 201.47,29.71 200.68,28.91 v1(200.47,28.91) ; U1.BM42 192.22,66.06 v1(192.45,65.83)
  ART06 w0.108: v1(200.47,28.91) 199.86,28.3 199.86,27.44 200.27,27.03 200.27,21.72 198.37,19.82 185.68,19.82 182.51,22.99 182.51,28.1 183.42,29.01 183.42,31.09 183.18,31.33 183.18,37.3 184.24,38.36 184.24,38.77 184.35,38.88 184.72,38.88 184.83,38.99 184.83,39.21 184.72,39.31 184.35,39.31 184.24,39.42 184.24,39.64 184.35,39.75 184.72,39.75 184.83,39.85 184.83,40.07 184.72,40.18 184.35,40.18 184.24,40.29 184.24,40.5 184.35,40.61 184.72,40.61 184.83,40.72 184.83,40.93 184.72,41.04 184.35,41.04 184.24,41.15 184.24,41.89 190.08,47.73 190.08,50.71 190.53,51.15 190.53,61.32 190.4,61.45 190.4,62.07 191.44,63.11 191.44,64.82 v1(192.45,65.83)
M_0_CSB0_N: length 79.7
  TOP w0.109: v1(201.79,25.99) 201.99,25.99 202.34,25.64 202.34,25.09 202.22,24.97 202.22,24.05 CN11.165
  TOP w0.135: v1(191.49,66.37) 191.17,66.06 U1.BP42
  ART06 w0.108: v1(191.49,66.37) 191.17,66.05 191.17,65.47 190.79,65.1 190.79,63.48 189.3,61.98 189.3,59.26 189.18,59.14 189.18,57.78 189.73,57.23 189.73,51.29 189.09,50.65 189.09,48.33 183.05,42.3 183.05,38.96 182.09,38 182.09,32.27 180.78,30.96 180.78,23.4 185.15,19.02 198.86,19.02 202.3,22.46 202.3,26.03 202.18,26.15 201.95,26.15 v1(201.79,25.99)
M_A_A0: length 73.9
  TOP w0.076: U1.BB48 196.42,62.76 196.66,62.51 196.66,61.32 196.66,61.32 196.66,61.26 196.67,61.25 196.67,58.25 v1(197.44,57.49)
  TOP w0.135: v1(197.66,28.73) 195.93,30.46 195.93,36.68 196.06,36.81 196.33,36.81 196.47,36.68 196.47,35.1 196.6,34.96 196.87,34.96 197.01,35.1 197.01,36.68 197.14,36.81 197.41,36.81 197.55,36.68 197.55,35.1 197.68,34.96 197.95,34.96 198.09,35.1 198.09,37.22 197.88,37.42 195.64,37.42 195.24,37.03 195.24,33.77 194.97,33.5 CN11.144
  ART06 w0.108: v1(197.44,57.49) 197.67,57.49 198.32,56.84 198.32,56.77 198.32,56.76 198.32,51.77 199.59,50.5 199.59,49.87 203.23,46.23 207.05,46.23 209.36,43.92 209.36,39.38 201.92,31.94 201.7,31.94 201.08,31.32 199.76,31.32 197.66,29.21 v1(197.66,28.73)
M_A_A1: length 78.4
  TOP w0.076: U1.BL49 192.69,62.38 192.76,62.31 192.76,61.53 193.02,61.27 193.02,58.11 192.48,57.57 192.48,56.36 192.38,56.26 191.64,56.26 191.56,56.19 191.56,54.32 191.64,54.25 191.79,54.25 191.86,54.32 191.86,55.88 191.94,55.96 192.09,55.96 192.17,55.88 192.17,54.32 192.25,54.25 192.4,54.25 192.47,54.32 192.47,55.88 192.55,55.96 192.7,55.96 192.78,55.88 192.78,54.01 192.85,53.93 193.24,53.93 193.79,54.48 193.79,54.89 v1(193.59,55.09)
  TOP w0.135: CN11.133 192.22,25.95 192.38,26.11 192.72,26.11 192.88,26.26 192.88,26.57 192.72,26.73 192.38,26.73 192.22,26.88 192.22,27.22 v1(192.32,27.31)
  ART06 w0.108: v1(193.59,55.09) 193.59,55.14 193.89,55.45 194.11,55.45 194.25,55.3 194.25,54.72 194.13,54.6 193.85,54.6 193.75,54.5 193.75,54.28 193.87,54.16 194.13,54.16 194.25,54.04 194.25,51.19 194.86,50.59 194.86,43.96 196.59,42.23 196.59,37.53 196.48,37.42 196.26,37.42 196.15,37.53 196.15,41.92 196.06,42.02 195.84,42.02 195.72,41.9 195.72,36.96 195.62,36.86 195.4,36.86 195.29,36.97 195.29,42.87 195.19,42.97 194.95,42.97 194.86,42.88 194.86,36.85 194.17,36.16 194.17,33.76 191.87,31.46 191.87,30.4 192.58,29.69 192.58,27.57 v1(192.32,27.31)
M_A_A2: length 86.7
  TOP w0.135: U1.BG38 194.03,68.01 v1(194.31,67.73)
  TOP w0.155: CN11.132 191.97,33.55 191.66,33.87 190.88,33.87 190.38,34.37 190.38,41.34 190.53,41.5 190.84,41.5 191,41.34 191,34.98 191.17,34.81 191.48,34.81 191.62,34.94 191.62,41.96 191.36,42.21 188.9,42.21 188.44,41.75 188.44,35.33 188.61,35.15 188.92,35.15 189.06,35.28 189.06,41.34 189.2,41.48 189.51,41.48 189.68,41.32 189.68,34.69 v1(189.69,34.68)
  ART06 w0.108: v1(189.69,34.68) 189.69,35.01 188.36,36.34 188.36,37.78 192.99,42.4 192.99,50.63 192.6,51.01 192.6,57.57 194.08,59.05 194.08,61.64 194.91,62.47 194.91,64.63 194.68,64.86 194.68,67.41 194.35,67.73 v1(194.31,67.73)
M_A_A3: length 81.3
  TOP w0.076: U1.BL45 192.89,64.33 192.96,64.27 192.96,61.6 193.22,61.34 193.22,57.77 193.43,57.55 193.43,57.45 193.33,57.34 193.22,57.34 192.93,57.63 192.82,57.63 192.65,57.46 192.65,57.05 192.74,56.96 193.16,56.96 193.24,56.88 193.24,56.73 193.16,56.65 192.74,56.65 192.65,56.57 192.65,56.37 193.29,55.73 v1(193.59,55.73)
  TOP w0.135: v1(192,27.8) 191.72,27.52 191.72,26.71 191.55,26.54 190.22,26.54 190.07,26.39 190.07,26.08 190.22,25.92 191.55,25.92 191.72,25.75 CN11.131
  ART06 w0.108: v1(192,27.8) 191.91,27.71 191.91,27.14 192.12,26.93 192.54,26.93 192.9,27.3 192.9,29.84 192.19,30.55 192.19,31.28 194.5,33.58 194.5,35.1 194.61,35.21 194.82,35.21 194.93,35.1 194.93,34.43 195.04,34.32 195.25,34.32 195.36,34.43 195.36,35.53 195.25,35.64 194.61,35.64 194.5,35.75 194.5,35.97 194.64,36.11 195.61,36.11 196.08,36.58 196.24,36.58 196.57,36.25 196.72,36.25 196.88,36.4 196.88,36.56 196.54,36.89 196.54,37.04 197.03,37.53 197.03,42.92 196.93,43.03 196.31,43.03 196.2,43.13 196.2,43.35 196.31,43.46 196.93,43.46 197.03,43.56 197.03,44.36 197.15,44.47 197.36,44.47 197.47,44.37 197.47,39.54 197.58,39.42 197.8,39.42 197.9,39.52 197.9,44.75 197.69,44.96 196.71,44.96 196.6,44.85 196.6,44.06 196.49,43.95 196.28,43.95 196.17,44.06 196.17,44.85 196.06,44.96 195.85,44.96 195.74,44.85 195.74,44.06 195.63,43.95 195.41,43.95 195.31,44.06 195.31,45.28 195.41,45.39 196.93,45.39 197.03,45.5 197.03,45.96 196.67,46.32 196.52,46.32 196.1,45.89 195.94,45.89 195.79,46.05 195.79,46.2 195.96,46.37 195.96,46.67 195.17,47.46 195.17,50.55 194.45,51.27 194.45,56.99 194.31,57.13 194.06,57.13 193.97,57.03 193.97,56.1 v1(193.59,55.73)
M_A_A4: length 83.1
  TOP w0.076: U1.BJ46 193.52,63.77 193.52,63.54 193.51,63.53 193.51,63.5 193.51,63.5 193.51,63.21 193.51,63.21 193.51,63.2 193.49,63.12 193.49,62.95 193.51,62.86 193.51,62.85 193.51,62.79 193.52,62.78 193.52,62.61 193.51,62.6 193.51,62.56 193.51,62.56 193.51,62.14 193.65,62 193.65,61.98 193.67,61.96 193.67,61.67 193.65,61.65 193.65,61.52 193.53,61.4 193.53,60.99 193.53,58.7 193.53,58.43 193.53,58.29 193.96,57.87 193.96,56.37 194.12,56.21 194.12,54.8
  TOP w0.135: CN11.128 190.97,30.69 191.13,30.53 192.27,30.53 192.43,30.38 192.43,30.07 192.27,29.91 191.13,29.91 190.97,29.76 190.97,29.3 190.81,29.14 v1(190.23,29.14) ; v1(194.83,53.14) 194.87,53.09 194.87,50.41 194.49,50.03 191.08,50.03 190.94,49.9 190.94,49.63 191.08,49.49 194.09,49.49 194.23,49.35 194.23,49.08 194.1,48.95 191.08,48.95 190.94,48.82 190.94,48.55 191.08,48.41 194.09,48.41 194.23,48.27 194.23,48 194.1,47.87 190.36,47.87 190.03,48.2 190.03,50.27 190.4,50.64 193.05,50.64 193.34,50.93 193.34,51.54 194.12,52.32 194.12,54.8
  ART06 w0.108: v1(190.23,29.14) 191.59,27.79 191.59,27.01 191.97,26.62 192.67,26.62 193.22,27.17 193.22,30.07 192.54,30.75 192.54,31.17 197.41,36.04 197.41,38.54 198.25,39.38 198.25,45.23 195.48,48 195.48,50.55 194.83,51.21 v1(194.83,53.14)

# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCIO_OUT: length 24.5
  TOP w0.203: U1.AD7 v1(206.19,83.03)
  TOP w0.305: v1(200.34,89.67) 199.95,90.06 R283.1 R147.1 198.68,90.3 198.68,90.54 198.16,91.06 197.61,91.06 197.34,90.79 R146.1 R250.1 R343.1 195.8,90.63 195.34,91.09 194.62,91.09 194.08,90.55 R149.1 R106.1 R336.1 191.58,90.06 R169.1
  ART03 w0.305: v1(200.34,89.67) 200.53,89.48 200.53,87.04 200.42,86.93 200.42,86.49 200.78,86.13 201.61,86.13 201.69,86.05 204.05,86.05 204.74,85.36 204.74,84.71 205.08,84.37 206.24,84.37 206.66,83.95 206.66,83.38 206.31,83.03 v1(206.19,83.03)
+VCCLDOSTD_OUT_0P85: length 2.8
  TOP w0.203: U1.DW37 168.27,68.51 167.95,68.18 UC1.1
+VCCPDSW_3P3: length 0.5
  TOP w0.305: v1(176.14,71.81) 175.77,71.43 U1.DE31
+VCCPGPPR_3P3_1P8: length 0.5
  TOP w0.203: v1(175.44,74.34) 175.43,74.32 175.27,74.11 U1.DF26
  vias: v1(176.83,75.51)
+VCCPLL:
  vias: v1(186.5,84.61)
+VCCPRTC_3P3: length 0.6
  TOP w0.203: v1(174.83,70.16) 174.83,70.24 U1.DG33
+VCCSFR_OC: length 4.8
  TOP w0.12: v1(184.64,60.94) 184.64,60.99 184.53,61.1 U1.CG49
  TOP w0.203: v1(184.64,60.94) 184.64,60.49 C348.1 ; U1.CG38 v1(185.14,67.73) ; v1(185.2,65.72) 184.7,66.02 U1.CG42 184.83,66.05 185.02,66.22 185.13,66.32 v1(185.17,66.32) 185.14,66.42 184.76,66.63 184.71,66.66 U1.CG41
+VCCSTG_OUT_FUSE: length 2.1
  TOP w0.125: 214.16,70.9 U1.G33 ; U1.G33 214.16,70.41 ; U1.G33 213.67,70.41 ; 214.32,70.41 U1.F33 ; U1.F33 214.81,70.41 ; U1.F33 214.32,70.9
  vias: v1(214.26,71.11) v1(214.92,71.05)
+VCCSTG_OUT_LGC: length 24.6
  TOP w0.203: R141.2 214.09,90.77 214.09,89.6 R131.2 ; R137.2 215.08,89.58 215.08,91.1 215.08,91.11
  TOP w0.305: R141.2 214.66,91.11 215.56,91.11 R133.2 v1(215.58,91.67) ; U1.E5 v1(215.27,84.12)
  ART03 w0.406: 216.9,86.61 216.9,90.35 v1(215.58,91.67) ; 216.9,86.61 217.86,86.61 218.42,86.05 v1(218.42,85.26) ; 216.9,86.61 216.22,85.93 216.22,85.07 v1(215.27,84.12)
  BOTTOM w0.305: R122.1 v1(218.42,85.26) ; R889.2 210.88,85.52 R132.2 210.88,84.69 R135.2 211.04,84.49 211.75,83.77 214.92,83.77 v1(215.27,84.12)
+VDDQ_MEM: length 374.5
  TOP w0.125: 193.84,68.93 U1.BG36 194.07,69.16 194.1,69.16 ; 193.84,68.93 193.66,68.75 193.66,68.7 193.66,68.7 ; 193.84,68.93 193.84,68.93 194.05,68.72 ; 206.9,68.68 207.11,68.47 U1.AA37 206.87,68.23 ; U1.BT38 189.93,68.26 189.73,68.47 U1.BU37 189.73,68.47 189.92,68.66 ; U1.BT38 190.43,67.76 ; U1.BT38 190.43,68.26 ; 195.46,68.72 U1.BE37 194.97,68.72 ; U1.BL37 192.7,68.66 ; U1.BL37 192.72,68.31 ; U1.BL37 192.27,68.28 ; U1.BL37 192.22,68.68 ; 200.04,68.72 U1.AR37 199.54,68.72 199.54,68.72 U1.AT36 199.18,68.78 199.18,68.6 ; 194.55,68.72 U1.BF37 194.05,68.72 ; U1.AR36 200,68.68 ; U1.AR36 200.5,69.18 ; U1.AR36 200,69.18 ; U1.AR36 200.5,68.68 ; 205.07,69.18 U1.AE36 204.57,69.18 ; 206.44,68.72 U1.AC37 205.95,68.72 ; 200.91,69.18 U1.AN36 200.91,68.68 ; 200.46,68.72 U1.AP37 200.95,68.72 ; 197.25,69.18 U1.AY36 ; U1.AY36 197.25,68.68 ; U1.AY36 197.75,69.18 ; U1.AY36 197.75,68.68 ; 196.41,68.69 196.41,68.75 U1.BB36 ; U1.BN37 191.76,68.23 ; U1.BN37 191.77,68.69 ; U1.BN37 191.33,68.72 ; U1.BN37 191.33,68.26 ; 205.99,69.18 U1.AD36 ; U1.AD36 205.49,69.18 ; U1.AD36 205.99,68.68 ; 203.66,69.18 U1.AG36 204.16,69.18 ; 206.44,69.14 U1.AC35 205.95,69.14 ; 198.17,69.18 U1.AV36 ; U1.AV36 198.42,68.93 198.59,68.76 198.59,68.71 ; U1.AV36 198.17,68.68 ; 194.51,69.18 U1.BF36 ; U1.BF36 195.01,68.68 ; U1.BF36 195.01,69.18 ; U1.BF36 194.51,68.68 ; 195.42,68.68 U1.BD36 ; U1.BD36 195.42,69.18 ; U1.BD36 195.68,68.93 195.85,68.76 195.85,68.64 ; 205.03,69.64 U1.AD35 ; U1.AD35 205.03,69.14 ; U1.AD35 205.53,69.14 ; 198.21,68.72 U1.AW37 197.71,68.72 ; U1.BP39 190.85,67.61 ; U1.BP39 191.35,67.11 ; U1.BP39 191.15,67.36 v1(191.54,67.75) ; 202.74,69.18 U1.AJ36 203.24,69.18 ; 193.11,68.68 193.11,68.75 192.93,68.93 U1.BJ36 192.68,69.18 ; U1.BB36 196.84,68.68 ; U1.BB36 196.84,69.18 ; 190.85,67.76 U1.BP38 190.85,68.26 ; 202.32,68.69 U1.AL36 202.25,69.11 ; 196.8,68.72 U1.BA37 197.29,68.72
  TOP w0.127: U1.AF49 204.54,60.83 v1(204.64,60.73) ; U1.L49 212.16,62.68 212.16,61.06 v1(212.33,60.9) ; v1(209.67,60.92) 209.57,61.02 209.57,62.72 U1.T49 ; v1(202.3,60.81) 202.04,61.08 U1.AL49
  TOP w0.152: U1.BF49 194.54,61.04 v1(194.76,60.82) ; v1(207.12,60.71) 207.05,60.78 U1.AA49 ; v1(192.15,60.8) 192.03,60.91 U1.BM49 ; U1.AT49 199.54,60.7 v1(199.79,60.45) ; v1(197.26,60.85) 197.04,61.07 U1.BA49 ; v1(189.67,60.81) 189.53,60.95 U1.BU49
  TOP w0.203: v1(197.26,60.85) 197.31,60.8 C327.1 ; C320.1 207.17,60.09 207.17,60.66 v1(207.12,60.71) ; U1.L38 212.27,68.01 212.52,67.76 v1(212.57,67.76) ; v1(209.67,60.92) 209.67,60.56 209.95,60.27 209.95,60.12 C318.1 ; v1(189.67,60.81) 189.75,60.73 C334.1 ; CN19.199 210.72,14.78 212.07,16.13 v1(212.73,16.13) ; v1(202.3,60.81) 202.22,60.73 C321.1 ; v1(210.7,25.36) 210.72,25.34 210.72,24.05 CN11.199 ; v1(212.33,60.9) 213.11,60.11 C325.1 ; v1(194.76,60.82) 194.77,60.81 C328.1 ; C326.1 199.79,60.45 v1(199.79,60.45) ; v1(192.15,60.8) 192.13,60.78 C329.1 ; U1.N36 210.89,68.93 v1(210.52,68.56) ; U1.CA39 v1(187.89,67.1)
  TOP w0.25: v1(186.72,13.84) 186.72,13.84 CN19.111 ; CN19.117 188.22,11.27 ; CN11.117 188.22,23.03
  TOP w0.254: CN19.12 161.97,19.27 161.55,18.85 v1(161.47,18.85) ; 188.22,23.03 188.22,22.9 188.07,22.74 v1(187.97,22.74) ; v1(201.75,25.34) 201.72,25.31 201.72,24.05 CN11.163 ; CN11.75 177.78,24.11 v1(177.78,25.39) ; v1(189.98,30.97) 189.96,30.98 189.96,32.24 CN11.124 ; v1(192.98,30.97) 192.97,30.98 CN11.136 ; CN19.220 215.97,19.48 216.01,19.45 216.04,19.45 v1(216.06,19.42) ; v1(188.43,30.88) 188.47,30.93 CN11.118 ; CN11.54 172.47,30.77 v1(172.98,30.27) ; CN11.147 197.72,24.05 v1(197.72,25.33) ; CN11.123 189.74,24.04 189.74,23.04 189.74,22.81 v1(189.72,22.8) ; v1(199.22,13.79) CN19.153 ; v1(188.36,18.44) 188.39,18.44 188.47,18.53 CN19.118 ; CN11.241 221.22,24.05 221.22,25.71 222.03,26.51 v1(222.22,26.51) ; v1(200.72,25.33) 200.72,24.05 CN11.159 ; CN19.112 186.97,18.96 v1(186.51,18.5) ; 201.1,33.73 201.1,33.67 201.08,33.65 201.01,33.65 200.97,33.61 200.97,32.25 CN11.160 ; v1(177.72,13.84) CN19.75 ; CN19.33 167.22,14.96 166.63,15.55 v1(166.22,15.55) ; v1(161.41,29.8) 161.54,29.8 161.97,30.23 CN11.12 ; CN19.124 189.96,20.7 189.96,18.37 v1(189.97,18.37) ; v1(201.62,13.79) 201.72,13.69 CN19.163 ; v1(191.46,18.47) 191.47,18.48 CN19.130 ; CN11.96 182.97,30.97 v1(182.98,30.97) ; v1(172.47,19.43) CN19.54 ; CN19.129 191.22,11.27 ; v1(186.98,30.97) 186.97,30.97 CN11.112 ; CN19.135 192.72,11.24 ; CN19.123 189.74,11.27 ; v1(199.22,14.37) 199.24,14.39 200.18,14.39 200.72,13.85 CN19.159 ; v1(194.48,30.97) 194.47,30.98 CN11.142 ; CN11.33 167.22,24.05 167.22,26.5 166.63,27.09 v1(166.22,27.09) ; v1(192.97,18.54) 192.97,18.55 CN19.136 ; v1(199.51,18.22) 199.51,18.54 199.46,18.59 199.46,20.7 CN19.154 ; v1(199.22,25.33) 199.22,24.05 CN11.153 ; CN19.147 v1(197.72,13.79) ; v1(182.98,19.43) 182.97,19.44 CN19.96 ; v1(197.62,18.59) 197.62,18.75 197.97,19.1 CN19.148 ; v1(194.48,18.63) 194.47,18.64 CN19.142 ; CN11.111 186.72,22.76 v1(186.69,22.72) ; CN11.129 v1(191.22,22.8) ; v1(222.22,14.97) 222.03,14.97 221.22,14.17 CN19.241 ; 193.9,10.92 193.9,11.12 194.22,11.45 CN19.141 ; v1(191.48,30.97) 191.47,30.97 CN11.130
  TOP w0.305: v1(198.9,33.6) 199.3,33.6 199.47,33.42 CN11.154 ; v1(192.29,22.22) 192.32,22.19 192.36,22.19 192.64,22.48 ; CN19.160 200.97,19.48 v1(200.93,19.44) ; CN11.135 192.72,22.56 192.64,22.48 ; CN19.178 v1(205.47,19.43) ; v1(201.1,33.75) 201.1,33.73 201.22,33.61 205.16,33.61 ; CN11.199 210.72,22.88 210.9,22.7 221.02,22.7 221.22,22.9 CN11.241 ; CN11.141 194.22,22.96 193.74,22.48 192.64,22.48 ; CN11.148 197.97,33.34 197.6,33.71 197.54,33.71 197.49,33.66 v1(197.49,33.64) ; CN19.111 186.72,10.24 186.34,9.85 ; CN11.220 215.97,33.41 215.38,34.01 205.56,34.01 205.16,33.61 ; 205.16,33.61 205.47,33.3 CN11.178 v1(205.47,30.97)
  TOP w0.406: 113.4,53.03 115.6,53.03 v1(116.22,53.65) ; 113.4,53.03 113.12,53.03 ; 113.4,53.03 113.11,52.74 ; 113.12,53.03 112.81,53.03 ; 113.12,53.03 113.11,53.03 113.11,52.74 ; 112.81,53.03 113.1,52.74 113.11,52.74 ; 112.81,53.03 109.05,53.03 108.52,53.56 105.23,53.56 104.58,54.21 104.58,56.92 105.89,58.22 108.81,58.22 v1(108.87,58.15) ; 113.11,52.74 v1(113.11,51.48)
  TOP w0.508: 191.22,10.54 191.22,9.88 191.2,9.85 ; 191.22,10.54 191.22,11.27 ; 191.22,10.54 191.04,10.54 190.36,9.85 189.67,10.55 ; 191.22,10.54 191.35,10.54 192.03,9.85 192.7,10.52 192.72,10.52 ; 189.74,11.27 189.74,10.55 ; 189.74,10.55 189.67,10.55 ; 189.74,10.55 189.74,9.85 189.74,9.85 ; 188.16,9.85 188.22,9.92 188.22,10.51 ; CP3.1 132.64,49.58 118.53,49.58 117.86,48.91 109.35,48.91 v1(108.52,49.73) ; 188.22,10.51 188.24,10.51 188.89,9.85 189.58,10.55 189.67,10.55 ; 188.22,10.51 188.22,10.51 187.57,9.85 ; 188.22,10.51 188.22,11.27 ; 192.72,10.52 192.77,10.52 193.44,9.85 193.9,10.31 193.9,10.92 ; 192.72,10.52 192.72,11.24 ; 192.72,10.52 192.72,9.88 192.7,9.85
  TOP w1.016: v2(154.94,19.75) 156.06,18.63 156.06,12.99 159.2,9.85 193.44,9.85
  ART03 w0.305: v1(189.5,88.47) 188.33,88.47 187.47,87.61 187.47,86.04 188.01,85.5 188.92,85.5 189.27,85.15 189.27,81.91 188.81,81.44 184.05,81.44 183.68,81.07 183.68,78.68 183.93,78.43 183.93,72.84 184.8,71.97 184.8,70.68 184.67,70.55 184.67,69.27 185.03,68.91 186.66,68.91 187.08,68.48 189.95,68.48 v1(190.65,67.79)
  ART06 w0.406: v1(116.22,53.65) 116.22,53.34 117.85,51.71 129.39,51.71 v2(129.47,51.63)
  BOTTOM w0.102: R750.2 184.28,24.54 R742.1
  BOTTOM w0.203: v1(116.22,53.65) 116.08,53.8 U2.19 ; U2.5 113.39,52.18 113.11,51.91 v1(113.11,51.48)
  BOTTOM w0.305: 148.68,54.99 148.68,55.01 ; 148.68,54.99 148.68,54.44 ; 148.68,54.99 148.42,54.72 ; 148.68,55.01 148.68,56.6 147.95,57.33 145.54,57.33 R794.2 ; 148.68,55.01 149.02,54.67 ; C891.2 221.68,26.45 222.17,26.45 v1(222.22,26.51) ; C199.2 R123.2 109.75,49.82 R127.2 109.04,49.22 v1(108.52,49.73) ; v1(222.22,14.97) 221.72,15.48 C162.2 221.46,15.59 220.67,16.38 214.84,16.38 ; 182.79,32.21 182.8,32.23 R747.2
  BOTTOM w0.406: v1(108.87,58.15) 108.87,57.77 108.49,57.39 U50.5
  BOTTOM w0.508: R855.1 189.47,88.51 v1(189.5,88.47)
  vias: v1(183.97,29.15) v1(187.14,60.84) v1(190.12,69.54) v1(190.88,69.49) v1(191.55,67.13) v1(191.71,69.51) v1(192.59,69.49) v1(194.06,69.57) v1(194.75,69.58) v1(195.52,69.56) v1(196.74,69.55) v1(197.49,69.47) v1(198.14,69.47) v1(199.47,69.57) v1(200.15,69.54) v1(200.91,69.5) v1(202.28,69.48) v1(203.06,69.52) v1(204.05,69.94) v1(203.98,18.22) v1(204.82,69.76) v1(205.28,70.23) v1(206.19,70.28) v1(206.18,15.55) v1(208.99,18.26) v1(211.68,66.46) v2(140.81,52.04) v2(140.8,51.32) v2(140.81,50.54) v2(141.55,51.85) v2(141.55,50.33) v2(141.56,51.1) v2(142.31,51.75) v2(142.33,51.03) v2(142.32,50.26) v2(142.97,51.45) v2(142.96,50.65) v2(151.51,29.54) v2(151.53,28.77) v2(151.5,27.97) v2(152.39,29.54) v2(152.4,28.77) v2(152.37,27.97) v2(154.89,24.64) v2(154.86,23.84) v2(154.91,23.07) v2(154.93,22.24) v2(154.94,21.46) v2(154.94,20.59) v2(159.38,51.12)
+VDDQ_VTT: length 189.8
  TOP w0.203: CN11.258 225.47,30.15 225.48,30.15
  TOP w0.305: v2(227.26,17.78) 227.26,17.98 226.67,18.58 225.75,18.58 225.47,18.86 CN19.258
  TOP w0.508: v1(227.87,29.71) 225.92,29.71 225.48,30.15
  PWR05 w1.016: v2(152.59,19.75) 152.59,17.46 157.78,12.27 226.38,12.27 228.28,14.17 228.28,17.54 228.04,17.78 v2(227.26,17.78)
  ART06 w0.508: v2(115.78,52.23) 115.65,52.1 111.04,52.1 110.41,52.73 106.9,52.73 106.43,52.27 v1(106.43,52.24)
  ART06 w0.813: v2(152.59,19.75) 152.2,19.75 150.51,21.44 149.45,21.44 147.74,23.15 147.74,30.37 152.05,34.68 152.05,36.54 151.62,36.98 151.62,38.52 150.78,39.35 147.86,39.35 137.66,49.55 137.66,50.26 135.23,52.68 118.05,52.68 v2(117.95,52.79)
  BOTTOM w0.508: 227.05,17.99 227.05,19.69 225.62,21.13 C177.2 225.66,22.57 C179.2 225.64,23.59 C181.2 225.66,24.39 C178.2 C180.2 225.66,28.32 227.04,29.71 v1(227.87,29.71) ; 227.05,17.99 226.9,17.99 225.94,17.02 C905.2 225.85,16.25 C906.2 225.86,15.45 C908.2 C907.2 226.51,13.95 C904.2 ; 227.05,17.99 v2(227.26,17.78) ; R799.2 107.32,53.63 106.43,52.74 v1(106.43,52.24)
AGND: length 225.7
  TOP w0.203: v1(27.92,76.65) 28.48,76.65 28.79,76.97 U25.38 ; U25.25 27.69,82.96 v1(27.44,83.21) ; ACN1.2 151.5,111.63 C6125.2 150.73,112.28 138.67,112.28 137.35,110.95 134.39,110.95 132.38,112.97 v1(131.38,112.97) 131.33,112.97 130.82,112.45 130.31,112.45 130.01,112.76 130.01,113.55 130.47,114.02 132.63,114.02 134.92,111.73 137.04,111.73 138.32,113.01 148.81,113.01 150.17,114.37 155.34,114.37 ACN1.E2
  TOP w0.305: C499.1 22.24,88.14 v1(22.19,88.19) ; R389.1 v1(25.43,83.49) ; ACN1.E2 ACN1.E1 154.53,110.33 ACN1.2 ; C464.1 24.33,84.3 v1(24.34,84.31) ; C472.1 26.34,72.87 26.34,72.86 v1(26.34,72.62) ; v1(27.01,73.27) 27.55,73.81 C469.2 27.49,73.97 C468.1 ; C501.1 v1(12.08,93.98) ; v1(32.6,89.15) 32.72,89.15 33.01,88.87 C475.1 ; C458.2 v1(23.57,83.07) ; C456.1 23.59,81.84 v1(23.6,81.84) ; C500.1 v1(19.12,86.38)
  TOP w0.508: C463.1 27.09,83.61 v1(27.12,83.63)
  TOP w0.762: FB22.2 v2(18.84,85.8)
  ART06 w0.305: v1(131.38,112.97) 131.33,112.97 130.87,112.51 130,112.51 129.02,113.49 112.57,113.49 111.82,112.74 90.14,112.74 89.55,113.33 85.98,113.33 85.4,112.74 83.8,112.74 82.52,111.46 78.15,111.46 75.96,113.65 65.92,113.65 62.71,110.44 56.17,110.44 54.92,111.69 33.91,111.69 32.82,112.77 23.49,112.77 20.52,109.8 20.52,98.28 19.74,97.49 19.74,90.32 20.12,89.94 22,89.94 22.8,90.74 32.3,90.74 32.85,90.18 32.85,89.4 v1(32.6,89.15)
  BOTTOM w0.406: C502.1 v2(8.25,93.22)
AVDD2_AUDIO: length 21
  TOP w0.203: U25.9 34.12,81.25
  TOP w0.305: 34.12,81.25 34.9,82.03 35.36,82.03 C485.2 35.6,82.27 C484.1 35.97,83.08 v1(36.23,82.83)
  TOP w0.406: FB25.1 28.42,71.21 FB24.1 28.42,71.35 v1(29.76,72.69)
  ART03 w0.406: v1(36.23,82.83) 36.23,81.81 34.81,80.38 34.81,76.29 32.41,73.9 30.97,73.9 v1(29.76,72.69)
AVDD33_REG: length 2.8
  BOTTOM w0.203: U30.23 71.12,67.8 69.9,66.58 ; C421.1 69.91,66.58
GND: length 2259.9
  TOP w0.076: v1(178.27,61.82) 178.27,62.52 U1.CY49 ; v1(193.31,61.82) 193.31,61.84 193.29,61.87 U1.BJ49 ; v1(182.79,60.97) 182.59,61.17 182.59,62.33 U1.CL49
  TOP w0.089: U1.DE22 175.46,75.58 U1.DF22
  TOP w0.1: v1(200.81,61.76) 200.79,61.78 U1.AN49 ; v1(195.81,61.77) 195.81,61.8 195.79,61.82 U1.BD49 ; v1(183.34,61.74) 183.28,61.81 U1.CK49 ; v1(173.22,61.69) 173.24,61.71 173.24,62.67 U1.DK49 ; v1(185.83,61.78) 185.82,61.79 185.82,61.81 185.78,61.85 185.78,62.31 185.78,62.54 U1.CE49 ; v1(203.3,61.82) 203.29,61.83 U1.AH49 ; v1(198.3,61.8) 198.27,61.83 198.27,62.69 U1.AV49 ; U1.N49 210.83,61.76 v1(210.9,61.68) ; v1(176.42,61.31) 176.42,61.56 176.4,61.58 U1.DC49 ; U1.CR49 v1(180.78,61.85) ; U1.CU49 v1(179.52,61.03)
  TOP w0.12: U1.A42 217.77,66.21 v1(217.83,66.14) ; U1.E6 214.89,83.58 214.55,83.92 214.38,83.92 U1.G5 213.94,84.15 213.65,83.86 ; U1.G49 v1(214.49,61.71) ; U1.H49 213.44,62.55 213.44,62.54 213.44,62.27 213.44,62.27 213.44,61.84 v1(213.53,61.75) ; v1(188.28,61.8) 188.28,61.8 U1.BY49 ; U1.A39 218.36,67.52 v1(218.63,67.42) ; v1(190.78,61.77) 190.78,61.77 U1.BR49 ; v1(208.33,61.64) 208.27,61.7 208.26,61.71 208.26,62.1 U1.V49 ; U1.AC49 205.8,61.75 v1(205.8,61.74) ; v1(217.87,68.9) 217.77,68.8 216.96,68.8 216.94,68.82 U1.A36
  TOP w0.127: U1.DN24 171.87,74.25 171.52,73.91 171.52,73.31 171.62,73.21 v1(171.62,72.98)
  TOP w0.15: v1(216.98,85.92) U1.B2 ; U1.C48 215.89,62.77 216.05,62.6 U1.C49 U1.A49 216.79,62.38 217.11,62.07 v1(217.13,62.07) ; v1(178.48,68.97) 177.6,68.97 177.57,69 U1.DB35 ; 213.65,83.86 213.63,83.86 213.61,83.83 213.34,83.83 213.29,83.88 212.54,83.88 212.33,83.81 212.16,83.81 211.97,83.86 U1.M5 ; v1(216.03,61.65) 215.4,62.28 U1.D49 ; v1(217.73,85.1) 217.25,85.1 U1.A3 217.06,84.91 216.53,84.91 U1.B3 ; U1.DH1 174.28,86.37 v1(174.41,86.51) ; U1.P8 210.27,82.29 210.27,81.11 U1.P11 ; v1(167.83,62.73) 168.11,62.73 168.18,62.8 168.4,62.8 U1.DW48
  TOP w0.152: CN11.23 164.72,25.05 164.68,25.1 164.68,25.66 164.41,25.93 v1(164.22,25.93)
  TOP w0.2: CN11.244 221.97,30.98 v1(221.99,30.97) ; v1(216.56,25.34) 216.72,25.18 216.72,24.05 CN11.223 ; CN11.89 181.22,24.05 v1(181.22,25.38) ; v1(222,19.43) 221.97,19.45 CN19.244 ; v1(216.56,13.8) 216.72,13.64 CN19.223 ; U1.AM2 U1.AL2 ; CN19.89 v1(181.22,13.84)
  TOP w0.203: U1.DL13 v1(172.17,79.41) 172.17,79.4 U1.DN15 ; v1(200.23,80.64) 200.25,80.66 200.25,80.99 U1.AR11 U1.AR9 v1(200.7,82.41) U1.AR7 v1(200.7,83.05) ; v1(204.36,82.38) U1.AG9 U1.AG11 203.91,80.6 v1(203.94,80.57) ; 174.58,79.26 174.58,79.01 U1.DG15 v1(174.79,78.49) ; U1.AG42 U1.AG41 ; U1.AG42 v1(204.36,65.83) ; U1.AG42 v1(204.36,66.46) ; U1.AG42 U1.AG43 ; U1.AG41 v1(204.36,66.46) ; U1.AG41 v1(204.36,67.1) ; U1.AG41 U1.AG39 ; v1(196.12,83.05) 196.06,83.05 U1.BD6 195.92,83.68 v1(196.12,83.68) v1(196.12,83.05) ; v1(196.12,83.05) U1.BB7 196.96,83 v1(197.05,82.98) 197.12,83 U1.AY7 v1(197.95,83.05) U1.AV7 v1(198.87,83.05) U1.AT7 v1(199.78,83.05) v1(199.78,83.68) ; v1(196.12,83.05) U1.BD7 v1(195.21,83.05) U1.BF7 194.33,83.02 194.33,83.02 194.31,83.03 v1(194.28,83.03) 194.23,83.03 194.18,82.98 U1.BG7 v1(193.38,83.05) 192.95,82.8 U1.BJ7 ; v1(194.31,66.46) 194.29,66.46 U1.BG41 v1(193.38,66.46) 192.95,66.7 U1.BJ41 ; U1.CT39 179.97,67.36 v1(180.32,67.71) ; U1.CA42 U1.CA41 187.89,66.46 v1(187.89,66.46) 187.62,66.22 U1.CA42 ; U1.CA42 v1(187.89,65.83) U1.CA43 ; U1.CA42 U1.CA43 ; v1(199.78,84.32) v1(199.78,83.68) ; v1(199.78,84.32) U1.AT5 v1(199.78,83.68) ; v1(199.78,84.32) U1.AT3 ; v1(199.78,83.68) U1.AT6 ; U1.AL45 202.04,64.14 v1(202.02,64.12) 202.04,64.1 U1.AL47 ; U1.AL45 201.29,65.41 U1.AN43 ; U1.AL45 201.61,64.66 201.57,64.7 200.83,64.7 U1.AN45 200.74,64.7 199.59,64.7 U1.AT45 ; U1.AL45 202.49,64.66 202.52,64.69 202.81,64.69 202.84,64.66 U1.AH45 203.72,64.66 203.75,64.69 204.08,64.69 204.11,64.66 U1.AF45 ; U1.DE45 175.82,64.71 176.97,64.71 U1.DB45 ; U1.BP3 191.27,84.64 v1(191.56,84.48) ; R1389.2 172.82,56.47 171.78,55.43 171.14,55.43 R384.2 ; U1.DJ33 v1(173.51,70.31) ; U1.BG3 193.38,84.95 193.11,85.23 U1.BJ2 U1.BJ1 v1(193.11,86.57) ; v1(189.81,84.86) 189.65,84.92 U1.BV3 ; v1(189.81,84.86) 189.81,84.86 189.93,84.74 U1.BT3 190.41,84.74 190.82,85.14 U1.BP2 U1.BP1 191.16,86.16 v1(190.83,86.49) ; v1(189.81,84.86) U1.BV2 ; U1.BT42 v1(190.63,66.46) ; U1.BT42 v1(190.63,65.83) ; U1.BT42 U1.BT43 ; U1.BT42 U1.BT41 ; v1(190.63,66.46) v1(190.63,67.1) U1.BT39 U1.BT41 ; v1(190.63,66.46) v1(190.63,65.83) ; v1(190.63,66.46) U1.BT41 ; v1(195.29,85.03) 195.58,84.74 U1.BD3 196.03,84.38 ; v1(195.29,85.03) 195.06,85.26 U1.BE2 U1.BE1 v1(195.06,86.56) ; v1(195.29,85.03) 194.99,84.74 U1.BF3 ; 175.77,68.94 175.77,67.72 v1(175.71,67.65) 175.41,67.36 U1.DF39 ; 175.77,68.94 175.41,69.31 U1.DF35 ; 175.77,68.94 176.05,68.66 U1.DD37 176.55,68.44 v1(176.71,67.68) 176.88,67.85 176.96,67.85 176.97,67.85 176.97,67.85 U1.DB38 v1(177.57,67.73) ; U1.AB5 206.72,84.66 206.73,84.72 v1(206.72,84.73) U1.AB3 ; U1.AE6 205.17,83.09 v1(205.25,83.09) ; v1(204.36,66.46) v1(204.36,65.83) ; v1(204.36,66.46) v1(204.36,67.1) ; DR1.1 233.13,49.73 233.21,49.81 v1(233.21,49.87) ; v1(180.86,71.39) 180.86,70.96 U1.CR32 ; U1.BU45 189.47,64.72 188.34,64.72 U1.BY45 188.22,64.72 187.44,64.72 ; U1.BU45 189.61,64.74 190.18,64.74 ; U1.BU45 189.46,64.59 v1(189.46,64.06) 189.53,63.99 U1.BU47 ; CN22.33 139.74,100.61 v1(139.58,100.45) ; v1(176.16,72.62) 176.16,72.65 175.8,73.08 U1.DE28 175.76,73.1 v1(175.44,73.51) ; U1.CM47 182.03,64.11 v1(182.04,64.12) 182.04,64.64 U1.CM45 ; v1(215.54,72.03) v1(216.19,72.03) ; v1(215.54,72.03) v1(214.89,72.03) ; v1(215.54,72.03) U1.D31 v1(214.89,72.03) ; v1(216.19,72.03) U1.B31 216.52,71.57 v1(216.84,72.03) ; v1(216.19,72.03) v1(216.84,72.03) ; v1(216.19,72.03) U1.C31 ; U1.CA43 187.44,64.72 ; 187.44,64.72 187.38,64.66 U1.CB45 ; U1.AA47 v1(207.05,64.13) U1.AA45 ; U1.K11 212.55,80.98 v1(212.24,81.29) ; v1(190.63,65.83) U1.BP43 190.78,65.09 U1.BR45 ; v1(190.63,65.83) U1.BT43 ; U1.DW27 168.98,73.75 U1.DU27 169.72,73.75 169.79,73.67 v1(169.9,73.67) 169.99,73.67 170.06,73.75 U1.DT27 ; v1(109.7,115.44) 110.03,115.11 SW1.E1 ; R917.1 v1(21.42,113.2) ; U1.BF47 194.54,64.06 v1(194.54,64.07) 194.54,64.66 U1.BF45 ; U1.AV43 U1.AV42 ; U1.AV43 198.42,64.97 198.29,64.84 U1.AV45 ; U1.AV43 v1(198.87,65.83) ; U1.AV42 v1(198.86,66.44) ; U1.AV42 U1.AV41 ; U1.AV42 v1(198.87,65.83) ; 192.93,64.77 192.93,65.39 U1.BJ43 ; 192.93,64.77 U1.BM45 191.99,64.7 190.82,64.7 U1.BR45 ; 192.93,64.77 U1.BJ45 193.33,64.7 194.49,64.7 U1.BF45 ; v1(176.09,74.34) U1.DE23 175.89,74.9 v1(176.09,75.17) U1.DE22 v1(176.09,76) U1.DE20 v1(176.09,76.83) U1.DE18 175.82,77.3 v1(176.09,77.66) U1.DE17 175.77,78.07 176.19,78.48 ; U1.AB41 U1.AB42 ; U1.AB41 v1(207.1,66.46) ; U1.AB41 v1(207.1,67.1) ; U1.AB41 U1.AB39 ; U1.AB42 v1(207.1,66.46) ; U1.AB42 v1(207.1,65.83) ; v1(198.87,67.1) 198.87,66.44 v1(198.86,66.44) ; v1(198.87,67.1) U1.AV39 ; v1(198.87,67.1) U1.AV41 ; v1(198.87,67.1) v1(198.87,67.73) ; U1.F45 214.64,64.69 213.91,64.69 213.88,64.66 U1.H45 213.41,64.69 212.64,64.69 212.61,64.66 U1.L45 ; U1.F45 214.56,64.54 v1(214.56,64.04) 214.56,63.57 U1.F47 ; U1.F45 215.06,64.66 U1.D44 ; U1.M3 211.67,84.66 v1(211.68,84.65) 211.67,84.63 U1.M5 ; v1(204.36,65.83) U1.AG43 ; U1.AG43 203.91,65.29 U1.AF45 ; U1.AF45 204.47,64.59 v1(204.47,64.06) ; U1.AF45 204.58,64.69 205.76,64.69 U1.AC45 206.25,64.66 206.28,64.69 206.57,64.69 206.6,64.66 U1.AA45 ; U1.CG45 184.61,64.74 185.7,64.74 U1.CE45 185.83,64.7 186.98,64.7 U1.CB45 ; U1.CG45 184.53,64.13 184.5,64.11 v1(184.5,63.99) 184.53,63.99 U1.CG47 ; U1.CG45 184.53,65.24 U1.CG43 183.98,65.83 183.96,65.84 U1.CJ42 ; U1.CG45 184.45,64.74 183.36,64.74 U1.CK45 183.22,64.72 182.08,64.72 U1.CM45 ; U1.DE33 175.77,70.68 v1(175.44,71.01) 175.44,70.92 U1.DF33 ; v1(207.1,67.73) U1.AB39 ; v1(207.1,67.73) U1.Y38 ; v1(207.1,67.73) v1(207.1,67.1) ; v1(207.1,67.73) 206.65,68.01 U1.AB38 U1.AB39 ; U1.AB39 v1(207.1,67.1) ; v1(204.36,67.1) U1.AG39 ; v1(204.36,67.1) v1(204.36,67.73) ; v1(196.12,67.1) v1(196.12,66.46) ; v1(196.12,67.1) U1.BD39 ; v1(196.12,67.1) U1.BD41 ; v1(196.12,67.1) v1(196.12,67.73) ; v1(196.12,66.46) U1.BD41 ; v1(196.12,66.46) U1.BD42 ; v1(196.12,66.46) v1(196.12,65.83) ; R361.2 47.11,73.63 47.37,73.9 v1(47.37,73.93) ; U1.DT42 170.06,65.89 v1(169.95,65.77) ; U1.AV41 v1(198.86,66.44) ; U1.AV41 U1.AV39 ; v1(198.86,66.44) 198.86,65.83 v1(198.87,65.83) ; v1(206.16,81.19) 206.13,81.21 206.09,81.21 U1.AD10 v1(206.19,81.76) ; v1(206.16,81.19) 206.14,81.09 U1.AD11 ; v1(206.16,81.19) 206.17,81.18 206.18,81.13 U1.AB11 v1(207.1,81.13) ; v1(192.46,83.05) U1.BM6 v1(192.46,83.68) ; v1(192.46,83.05) U1.BM7 191.87,82.85 v1(191.55,83) U1.BP7 ; v1(192.46,83.05) v1(192.46,83.68) ; U1.L41 U1.L39 v1(212.59,67.1) v1(212.59,66.46) ; U1.L41 U1.L42 ; U1.L41 v1(212.59,66.46) ; v1(217.75,64.69) 217.64,64.79 U1.A44 ; U1.E39 214.95,67.46 v1(215.56,67.46) 215.61,67.52 U1.C39 ; U1.E39 214.89,68.01 214.87,68.03 214.87,68.31 214.89,68.33 U1.E36 214.72,69 214.72,69.9 U1.E34 215.45,70.07 v1(215.46,70.06) 215.48,70.07 U1.C34 U1.A34 ; U1.E39 214.86,67.49 214.86,66.72 214.89,66.69 U1.E42 ; U1.AU37 198.88,67.74 v1(198.87,67.73) ; U1.AU37 U1.AV38 ; U1.AU37 198.88,69.22 v1(198.88,69.22) ; v1(192.46,84.32) U1.BM5 v1(192.46,83.68) ; v1(192.46,84.32) U1.BM3 ; v1(192.46,84.32) v1(192.46,83.68) ; v1(192.46,84.32) U1.BJ3 ; v1(211.62,82.15) 211.62,82.07 U1.M10 211.26,81.7 v1(210.9,82.16) U1.P8 ; U1.CM45 181.97,64.72 180.83,64.72 U1.CR45 180.73,64.7 179.56,64.7 U1.CU45 ; U1.J10 213.44,81.46 v1(213.44,81.25) ; v1(164.63,84.58) 164.1,84.05 164.1,83.39 164.56,82.93 166.42,82.93 167.2,82.15 167.91,82.15 168.45,81.61 U1.DW10 U1.DU10 U1.DV8 ; U1.AB6 207.04,83.63 207.07,83.62 v1(207.13,83.65) ; U1.W37 208.03,67.74 v1(208.02,67.73) 207.86,67.83 U1.Y38 ; U1.W37 U1.U37 ; U1.W37 U1.Y36 U1.V36 ; U1.W37 U1.Y38 ; Q80.2 84.63,71.38 v1(84.83,71.58) ; R920.1 v1(39.42,107.17) ; U1.DT32 170.09,71.13 v1(169.91,71.31) 169.73,71.13 U1.DU32 ; U1.BF45 194.98,64.66 195.01,64.69 195.3,64.69 195.33,64.66 U1.BD45 ; v1(200.63,85.05) 200.91,85.32 U1.AN2 U1.AM2 ; v1(200.63,85.05) 200.32,84.74 U1.AR3 199.78,84.95 U1.AT3 ; v1(200.63,85.05) 200.26,85.43 U1.AR2 U1.AR1 ; v1(214.89,72.03) U1.F31 v1(214.24,72.03) ; v1(214.89,72.03) v1(214.24,72.03) ; 213.59,71.11 U1.H31 v1(213.59,72.03) U1.G31 ; 213.59,71.11 U1.G31 ; 213.59,71.11 213.57,71.08 U1.H33 U1.K33 211.48,70.66 v1(211,71.14) ; U1.BA45 197.02,64.68 196.57,64.68 196.56,64.69 196.27,64.69 196.26,64.68 195.81,64.68 U1.BD45 ; U1.BA45 197.04,64.18 v1(197.02,64.16) 197.04,64.14 U1.BA47 ; U1.BA45 197.07,64.69 197.91,64.69 197.94,64.66 U1.AV45 ; U1.AN41 U1.AN42 ; U1.AN41 v1(201.61,66.47) U1.AN42 ; U1.AN41 U1.AN39 ; U1.AN41 v1(201.61,67.1) U1.AN39 ; U1.AN42 v1(201.61,65.84) U1.AN43 ; U1.AN42 U1.AN43 ; v1(216.84,74.77) U1.B24 U1.C24 v1(216.19,74.77) ; v1(175.44,73.51) 175.63,73.49 175.76,73.48 176.14,73.45 v1(176.17,73.45) ; v1(175.44,73.51) U1.DF28 ; 211.8,68.56 v1(211.25,68.56) 211.25,68.57 U1.M36 ; U1.DW46 168.17,64.14 v1(167.98,63.95) ; U1.DJ19 174.11,76.8 v1(174.11,76.76) ; U1.AL6 v1(202.53,83.19) ; U24.8 v1(147.46,98.05) ; U1.DT37 170.06,68.51 169.91,68.36 v1(169.87,68.36) 169.72,68.51 U1.DU37 ; U1.AG38 U1.AH37 ; U1.AG38 U1.AG39 ; U1.AG38 v1(204.36,67.73) ; U1.AG38 204.37,68.47 U1.AF37 ; U1.AH37 U1.AK37 ; U1.AH37 U1.AF37 ; v1(212.06,64.06) 212.06,64.59 U1.L45 ; U1.BD45 195.79,65.29 U1.BD43 ; U1.G31 v1(214.24,72.03) ; U1.AG39 v1(204.36,67.73) ; U1.DF13 U1.DE13 U1.DE15 175.12,79.55 U1.DF13 ; U1.DF13 175.01,79.62 174.58,79.62 ; U1.DF13 175.12,79.8 174.78,80.14 174.47,80.45 ; U1.DE6 175.54,83.45 175.04,83.69 175.04,83.69 175.03,83.69 174.75,83.55 U1.DG6 174.63,83.8 U1.DH5 174.28,84.63 v1(174.29,84.65) 174.28,84.66 U1.DH3 U1.DH1 ; C6147.2 v1(18.61,113.61) ; U1.BR45 190.7,64.74 190.18,64.74 ; C320.2 207.93,59.25 v1(208.24,58.94) ; U1.DN42 171.65,65.89 v1(171.65,65.75) ; v1(201.62,69.22) U1.AM37 ; U1.AM37 201.62,67.74 v1(201.61,67.73) ; U1.AM37 U1.AN38 ; U1.U3 209.29,85.05 v1(209.57,85.05) 209.57,84.88 209.42,84.73 209.42,84.37 U1.U5 ; v1(216.84,72.03) U1.A31 v1(217.49,72.03) v1(216.84,72.03) ; U1.BD39 U1.BD38 ; U1.BD39 U1.BD41 ; U1.BD39 v1(196.12,67.73) ; U1.BD38 U1.BC37 ; U1.BD38 v1(196.12,67.73) ; C349.1 144.26,101.12 v1(144.06,101.32) ; U1.G36 v1(213.8,68.51) U1.H36 ; U1.V11 v1(208.93,81.13) U1.T11 v1(209.85,81.11) ; v1(167.95,65.53) 167.95,65.42 168.16,65.22 U1.DW44 U1.DV44 ; U1.CA3 187.03,84.33 ; U1.CA3 U1.BW3 ; U1.CA3 187.05,84.74 ; 187.03,84.33 187.03,84.71 187.05,84.74 ; 187.03,84.33 v1(187.03,83.09) ; U1.F11 v1(214.71,80.33) 215.18,79.87 U1.D13 ; U1.BC37 v1(196.13,69.25) ; U1.BC37 196.13,67.74 v1(196.12,67.73) ; U1.CV3 v1(179.23,84.69) U1.CV5 ; v1(189.49,86.51) 189.21,86.23 U1.BV1 U1.BV2 ; U1.CB45 187.01,64.64 v1(187.01,64.09) 187.03,64.07 U1.CB47 ; U1.CU45 179.47,64.71 178.33,64.71 U1.CY45 178.23,64.7 177.06,64.7 U1.DB45 ; U1.CU45 179.45,64.59 179.45,64.06 179.52,63.99 U1.CU47 U1.CU49 ; 187.05,84.74 U1.CC3 ; U1.DA10 v1(177.82,82.38) ; v1(177.82,82.38) U1.CY9 178.81,82.42 178.84,82.33 U1.CV9 v1(179.65,82.38) U1.CT9 180.57,82.38 U1.CP9 v1(181.48,82.38) U1.CM9 v1(182.4,82.38) 182.5,82.33 U1.CK9 v1(183.31,82.38) U1.CJ9 v1(184.23,82.38) U1.CG9 v1(185.14,82.38) U1.CE9 v1(186.06,82.38) ; v1(177.82,82.38) U1.DA9 ; U1.DU48 U1.DU49 U1.DW49 v1(168.42,61.87) ; U1.BV2 188.8,85.06 v1(188.8,84.95) ; U1.CV35 U1.CV34 179.27,69.73 v1(179.4,69.64) U1.CV35 ; U1.CV35 v1(179.4,69) ; U1.DL44 v1(172.21,64.82) ; R39.1 121.98,76.83 C333.1 121.98,75.52 v1(121.68,75.22) ; U1.AD34 v1(205.74,70.72) ; U1.DB45 177.02,64.66 177.02,63.85 v1(177.02,63.85) U1.DB47 U1.DB49 ; U1.G5 214.15,84.63 v1(214.16,84.65) 214.15,84.66 U1.G3 ; U1.T43 209.4,64.97 209.55,64.82 U1.T45 ; U1.CY41 v1(178.49,66.46) ; v1(174.79,76) U1.DF22 ; U1.Y9 v1(208.02,82.4) U1.V9 ; v1(187.89,67.73) U1.CA38 ; U1.CA38 186.98,68.47 U1.CB37 186.88,68.37 v1(186.06,68.37) U1.CE37 185.35,68.5 v1(185.14,68.37) U1.CG37 184.39,68.54 184.3,68.5 v1(183.98,68.37) 183.92,68.4 U1.CJ37 183.27,68.5 v1(183.06,68.37) U1.CL37 182.5,68.59 182.36,68.5 v1(182.15,68.37) U1.CN37 v1(181.23,68.37) U1.CR37 180.53,68.5 v1(180.32,68.37) U1.CT37 ; U1.CA38 187.89,68.46 U1.BY37 187.91,68.46 188.8,68.46 U1.BW37 ; v1(213.59,74.77) U1.H24 U1.G24 v1(214.24,74.77) ; U1.BD41 U1.BD42 ; v1(92.44,88.26) 92.45,88.24 U7.8 ; U1.DL10 v1(172.85,82.18) 172.85,82.19 U1.DK8 ; v1(196.09,84.38) 196.03,84.38 ; 196.03,84.38 195.97,84.38 U1.BD5 ; U1.AT3 199.12,84.95 v1(198.87,84.95) U1.AV3 198.41,84.76 198,84.95 197.53,84.73 U1.AY3 197.02,84.96 v1(197.02,84.97) 196.95,84.97 196.72,84.74 U1.BB3 196.59,84.76 196.39,84.96 v1(196.15,84.96) ; U1.DN36 171.65,68.59 171.65,68.56 v1(171.49,68.4) ; v1(212.59,66.46) v1(212.59,65.83) ; U1.AT45 199.51,64.63 v1(199.51,64.13) 199.54,64.1 U1.AT47 ; U1.AT45 199.4,64.8 198.71,64.8 198.56,64.66 U1.AV45 ; U1.DC3 U1.DC5 v1(176.92,83.61) U1.DC6 ; U1.U37 U1.V36 ; U1.U37 U1.R37 U1.T36 U1.V36 ; v1(138.72,97.3) 138.72,98.22 139.61,99.11 CN22.39 ; U1.AJ2 U1.AH2 203.51,84.98 v1(203.47,84.94) 203.26,84.74 U1.AJ3 202.75,84.74 v1(202.52,84.51) 202.52,84.98 202.21,85.3 U1.AL2 ; v1(198.87,67.73) U1.AV38 ; v1(198.87,67.73) U1.AV39 ; U1.AV38 U1.AV39 ; U1.K8 v1(212.81,83.06) ; v1(165.89,84.52) 166.04,84.52 167.61,82.95 167.72,82.95 v1(167.79,83.01) 167.88,82.92 U1.DW7 U1.DU7 169.47,82.86 170,82.86 U1.DT7 170.38,82.59 U1.DT8 U1.DT10 170.07,81.61 169.93,81.75 v1(169.84,81.75) ; v1(201.61,67.73) U1.AN38 ; v1(201.61,67.73) U1.AN39 ; U1.AN38 U1.AN39 ; U1.L45 212.1,64.69 210.86,64.69 U1.N45 210.8,64.69 209.58,64.69 U1.T45 ; U1.L45 212.13,65.4 U1.L43 ; U1.BD42 U1.BD43 ; U1.BD42 v1(196.12,65.83) ; U1.BW3 v1(188.8,84.32) ; U1.BW3 v1(188.8,84.95) ; v1(188.8,84.32) v1(188.8,84.95) ; v1(188.8,84.32) U1.BW5 v1(188.8,83.68) ; v1(188.8,84.32) v1(188.8,83.68) ; v1(47.54,91.05) 47.54,91.05 D35.P ; U1.DE10 U1.DG10 174.47,81.33 U1.DG12 ; v1(207.1,66.46) v1(207.1,65.83) ; U1.BV11 v1(189.27,80.57) ; U1.CH5 184.18,84.4 184.32,84.54 184.32,84.62 v1(184.27,84.67) 184.27,84.73 184.18,84.83 U1.CH3 ; U1.AA45 207.57,65.18 U1.Y43 v1(207.1,65.83) ; U1.AA45 207.48,64.66 207.51,64.69 208.27,64.69 U1.V45 208.33,64.69 209.52,64.69 U1.T45 ; U1.AA45 206.65,65.05 U1.AB43 v1(207.1,65.83) ; U1.BM11 192.01,80.69 v1(192.03,80.67) ; U1.BT43 190.18,64.74 ; U1.BD43 v1(196.12,65.83) ; v1(164.77,77.12) 164.68,77.12 164.53,77.26 C6140.1 ; C229.2 86.59,108.98 86.59,110.87 v1(86.54,110.92) ; U1.DN31 v1(171.56,71.22) ; D34.P 44.79,91.12 v1(44.79,91.12) ; U1.DW20 U1.DU20 169.67,76.37 169.84,76.19 v1(169.87,76.19) 169.9,76.19 170.08,76.37 U1.DT20 ; U1.L42 v1(212.59,65.83) ; U1.L42 U1.L43 ; U1.BM47 192.03,64.1 v1(192.03,64.1) ; U1.DJ42 v1(173.51,65.73) ; U1.AV11 v1(198.42,80.59) ; v1(212.59,65.83) U1.L43 ; U1.DH45 173.96,64.33 174.3,63.99 174.34,63.99 v1(174.36,63.96) 174.49,63.84 174.49,63.41 U1.DG47 ; v1(188.8,83.68) v1(188.8,83.05) ; v1(188.8,83.68) U1.BW6 v1(188.8,83.05) ; v1(188.8,83.05) U1.BV7 189.69,83.03 v1(189.81,83) U1.BT7 ; v1(188.8,83.05) U1.BW7 ; U1.CN5 181.72,84.17 181.72,84.68 v1(181.73,84.69) 181.7,84.72 U1.CN3 ; U1.A11 v1(217.47,81.11) ; U1.C6 215.7,83.58 v1(215.7,83.58) 215.69,83.58 U1.E6 ; v1(196.68,86.49) 197.01,86.16 U1.BA1 U1.BA2 ; v1(230.58,54.17) 230.55,54.17 230.23,53.85 230.23,50.65 230.59,50.29 231.1,50.29 231.33,50.07 R517.2 ; U1.AN6 201.61,83.19 v1(201.61,83.19) ; U1.CA7 v1(187.89,83.02) ; U1.E11 215.68,81.11 v1(215.7,81.13) 215.72,81.11 U1.C11 ; C326.2 199.79,58.23 v1(199.82,58.21) ; U1.J6 v1(213.44,83.08) ; U1.CC7 v1(186.97,82.38) ; U1.DT6 170.52,83.55 v1(170.76,83.79) ; U1.DW48 U1.DV48 ; U1.DJ31 v1(173.51,71.22) ; U1.DJ36 173.82,68.95 v1(173.44,69.33) ; U1.CT42 v1(180.32,65.83) ; v1(210.76,66.46) U1.P41 v1(209.85,66.46) U1.T41 ; v1(218.49,62.25) 217.9,62.84 U1.A48 217.05,62.84 216.88,63.01 U1.B48 ; v1(209.58,64.08) 209.55,64.04 U1.T47 ; U1.AD37 U1.AF37 ; U1.DJ27 v1(173.51,73.05) ; U1.BB11 196.24,80.86 v1(196.24,80.75) ; v1(173.5,76.66) 173.82,76.33 U1.DJ21 ; U1.BH37 v1(193.39,69.25) ; U1.CN39 v1(182.16,67.09) ; U1.DG22 174.76,75.21 v1(174.88,75.2) 174.85,75.16 174.79,75.15 U1.DG23 ; U1.DU15 169.72,78.99 U1.DT15 170.5,78.99 v1(170.81,79.3) ; v1(212.73,80.33) U1.J13 ; U1.DN19 v1(171.56,76.71) ; U1.CG39 v1(185.14,67.1) ; U1.P11 v1(210.9,80.32) ; U1.CL42 v1(183.06,65.83) ; U1.F8 v1(214.71,82.16) ; U1.DD42 v1(176.66,65.83) ; 177.12,70.88 U1.DB32 177.13,70.88 177.52,71.27 v1(177.68,71.27) 177.58,71.17 U1.DA33 177.12,70.88 ; U1.L36 v1(212.5,68.51) v1(211.85,68.51) U1.L36
  TOP w0.23: U1.D13 U1.C13
  TOP w0.25: CN19.185 207.22,13.67 v1(207.35,13.8) ; 211.22,25.51 211.22,24.05 CN11.201 ; CN19.26 165.47,18.57 v1(164.98,18.08) ; CN19.222 216.47,19.76 216.55,19.68 216.55,18.99 ; CN11.205 212.22,24.05 212.22,25.55 ; v1(213.52,30.97) 213.47,31.02 CN11.210 ; CN19.52 171.97,19.12 ; 204.72,13.51 v1(204.72,13.8) ; CN19.10 161.47,19.45 v1(161.47,19.45) ; CN11.48 170.97,30.98 170.99,30.96 v1(170.99,30.94) ; v1(172.47,18.26) 172.53,18.26 172.97,18.7 ; v1(170.97,19.43) CN19.48 ; CN19.210 213.47,19.44 v1(213.48,19.43) ; CN19.206 212.47,18.93 ; 217.51,19.06 217.47,19.1 CN19.226 ; CN11.19 163.72,24.05 163.72,25.67 ; CN11.226 217.54,32.19 217.54,30.99 v1(217.55,30.98) ; v1(168.97,19.43) CN19.40 ; CN19.72 176.97,19.57 ; v1(181.48,29.8) 181.29,29.8 180.47,30.62 CN11.86 ; v1(209.72,14.39) 209.82,14.39 210.22,13.98 CN19.197 ; CN19.68 175.97,19.69 ; v1(181.48,18.26) 181.29,18.26 180.47,19.08 CN19.86 ; CN11.72 176.97,31.11 ; v1(179.48,19.43) 179.47,19.44 CN19.82 ; v1(214.56,15.55) 214.34,15.55 213.22,14.44 CN19.209 ; CN19.94 182.47,19.18 ; CN19.205 212.22,14.01 ; CN19.201 211.22,14.39 ; CN19.193 209.22,14.47 ; CN11.185 207.22,24.05 207.22,25.21 v1(207.35,25.34) ; CN11.68 175.97,31.23 ; CN19.218 215.47,19.67 ; v1(174.47,29.7) 174.97,30.2 CN11.64 ; v1(207.35,26.51) 207.55,26.51 208.22,25.84 208.22,24.05 CN11.189 ; CN11.40 v1(168.97,30.97) ; CN11.82 179.47,30.97 v1(179.48,30.97) ; CN11.214 214.47,30.6 v1(213.52,29.65) ; CN19.202 211.47,19.68 ; CN11.102 184.47,30.78 184.07,30.38 v1(183.98,30.38) ; v1(207.35,14.97) 207.55,14.97 208.22,14.3 CN19.189 ; v1(216.56,15.55) 215.69,15.55 215.22,15.09 CN19.217 ; 214.22,25.03 214.22,24.05 CN11.213 ; v1(216.56,27.09) 215.99,27.09 215.22,26.33 215.22,25.69 ; CN11.209 213.22,24.05 213.22,25.98 214.34,27.09 v1(214.56,27.09) ; CN19.196 209.97,19.62 ; CN11.26 165.47,30.52 ; CN11.1 159.22,24.05 v1(159.22,25.36) ; CN19.78 178.47,19.33 ; CN11.52 171.97,30.65 171.13,29.8 171.04,29.8 v1(171.02,29.78) ; v1(164.5,30.97) 164.47,30.99 CN11.22 ; v1(161.41,30.97) 161.47,31.03 CN11.10 ; CN19.6 160.47,18.79 ; CN19.102 184.47,19.24 184.07,18.84 v1(183.98,18.84) ; CN11.196 209.97,31.16 ; CN19.22 164.47,19.23 v1(164.98,18.72) ; v1(216.44,30.74) 216.47,30.77 CN11.222 ; CN19.1 v1(159.22,14.08) ; 212.47,31 CN11.206 ; CN11.6 160.47,30.4 ; CN11.197 210.22,24.05 210.22,25.52 209.82,25.93 v1(209.72,25.93) ; 204.72,25.05 v1(204.72,25.34) ; CN19.19 163.72,14.39 ; CN11.78 178.47,30.12 ; CN11.238 220.47,31.21 ; CN19.238 220.47,19.67 ; CN19.214 214.47,19.03 ; v1(163.47,19.43) CN19.18 ; CN11.193 209.22,26.01 ; CN19.64 174.97,19 ; 172.97,30.96 v1(172.98,30.96) ; CN11.94 182.47,30.72
  TOP w0.254: CN10.33 106.78,66.22 v1(106.72,66.17) ; CN19.99 183.72,14.03 183.32,14.43 v1(183.22,14.43) ; v1(175.72,14.43) 175.89,14.43 176.22,14.09 CN19.69 ; 220.47,19.67 220.47,18.31 221.14,17.64 221.98,17.64 v1(222,17.66) ; 204.72,25.05 204.72,24.05 CN11.175 ; v1(212.06,64.06) 212.13,63.99 U1.L47 ; v1(171.89,25.38) 171.72,25.21 171.72,24.05 CN11.51 ; v1(161.38,13.8) 161.22,13.64 CN19.9 ; v1(214.24,76.6) 213.91,76.28 U1.G21 U1.H21 213.27,76.28 v1(213.59,76.6) ; U1.C14 216.19,79.63 U1.C13 ; v1(168.99,29.79) 168.62,29.79 167.97,30.43 CN11.36 ; v1(215.48,19.43) 215.47,19.44 215.47,19.67 ; CN19.252 223.97,19.47 v1(224.01,19.43) ; v1(170.22,14.97) 170.72,14.47 CN19.47 ; CN10.21 109.28,69.22 110.05,70 v1(110.2,70) ; v1(170.72,25.32) 170.72,25.31 170.72,24.05 CN11.47 ; v1(212.72,14.39) 212.6,14.39 212.22,14.01 ; CN19.61 174.22,14.03 173.83,14.43 v1(173.72,14.43) ; v1(207.79,19.42) 207.85,19.42 207.92,19.49 207.92,20.66 CN19.188 ; v1(122.73,80.22) 122.69,80.19 U20.8 ; U1.DU2 U1.DU1 169.39,86.7 v1(169.11,86.86) 169.33,86.82 169.41,86.7 169.8,86.63 170.13,86.13 U1.DT1 U1.DU2 ; U1.DU2 U1.DT3 ; v1(57.78,95.31) CN3.17 ; v1(159.47,19.43) 159.47,19.43 CN19.2 ; 178.47,30.12 177.55,29.2 v1(176.99,29.2) ; v1(180.22,25.38) 180.22,24.05 CN11.85 ; v1(181.48,30.97) 181.47,30.97 CN11.90 ; CN11.167 202.72,24.05 202.72,25.96 202.06,26.62 v1(201.83,26.62) ; U1.DE26 176.17,73.51 v1(176.17,73.45) 175.81,73.09 U1.DE28 ; U1.DE26 176.09,74.24 v1(176.09,74.34) ; U1.DE26 175.77,73.83 v1(175.44,73.51) ; v1(219.48,19.43) 219.47,19.44 CN19.234 ; 220.47,31.21 220.47,31.02 v1(220.56,30.93) ; CN19.243 221.72,14.02 222.09,14.39 v1(222.22,14.39) 222.37,14.39 222.72,14.03 CN19.247 ; v1(208.99,19.43) 208.97,19.44 CN19.192 ; CN11.31 166.72,24.05 166.72,25.63 166.43,25.93 v1(166.22,25.93) ; U1.AG3 204.22,85.25 204.22,85.71 U1.AG1 ; U1.AG3 203.7,85.14 203.5,84.94 v1(203.47,84.94) ; U1.AG3 U1.AG5 ; CN19.107 185.72,11.3 v1(185.62,11.2) ; v1(209.57,85.05) 209.81,84.81 U1.R3 ; CN11.98 183.46,32.24 183.46,29.62 183.06,29.21 v1(182.98,29.21) ; v1(201.65,14.39) 202.07,14.39 202.72,13.74 CN19.167 ; v1(214.26,78.38) 214.29,78.35 214.82,78.35 215.2,77.98 U1.D17 U1.C17 U1.B17 U1.A17 217.85,77.98 v1(217.86,77.96) ; 182.47,30.72 182.81,30.38 v1(182.98,30.38) ; v1(161.38,29.1) 162.47,30.2 CN11.14 ; CN19.184 206.97,19.89 206.91,19.83 206.91,19 207.68,18.23 v1(207.79,18.23) ; v1(214.56,25.93) 214.4,25.93 214.14,25.66 214.14,25.11 214.22,25.03 ; v1(109.31,69.97) 109.31,70.25 108.84,70.72 CN10.15 ; v1(175.72,26.55) 175.22,26.05 175.22,24.05 CN11.65 ; v1(211.85,68.51) 211.54,68.82 U1.M36 ; v1(205.47,30.38) 205.58,30.38 205.97,30.77 CN11.180 ; 211.22,25.51 v1(210.7,26.04) ; CN19.172 203.97,19.43 v1(203.98,19.43) ; U1.DG22 174.79,75.9 v1(174.79,76) ; v1(181.22,26.55) 181.36,26.55 182.22,25.69 182.22,24.05 CN11.93 ; v1(173.97,18.26) 174.23,18.26 174.97,19 ; CN19.57 173.22,14.99 172.56,15.66 171.88,15.66 171.87,15.65 171.87,15.64 v1(171.89,15.61) ; CN19.235 219.72,14.23 220.46,14.97 v1(220.72,14.97) ; CN11.2 159.47,30.97 v1(159.47,30.97) ; v1(202.97,29.8) 203.29,29.8 203.97,30.49 203.97,30.97 ; 178.47,19.33 v1(178.44,19.29) ; v1(160.24,13.87) 160.22,13.86 CN19.5 ; 173.17,83.88 173.13,83.91 v1(173.13,84.03) ; 173.17,83.88 173.17,84.04 173.04,84.17 U1.DK4 173.04,84.79 U1.DK3 ; 173.17,83.88 U1.DK6 ; v1(162.72,25.34) 162.72,24.05 CN11.15 ; v1(106.77,64.75) 106.8,64.72 CN10.39 ; v1(223.22,25.93) 223.33,25.93 223.72,25.53 223.72,24.05 CN11.251 ; 160.47,30.4 159.87,29.8 v1(159.47,29.8) ; CN19.43 169.72,14.07 170.04,14.39 v1(170.22,14.39) ; CN19.171 203.72,14.61 204.08,14.97 v1(204.72,14.97) ; v1(184.19,25.97) 184.26,25.97 184.72,25.51 184.72,24.05 CN11.103 ; 211.47,19.68 211.47,19.46 v1(211.46,19.44) ; v1(162.72,26.51) 162.89,26.51 163.72,25.67 ; CN11.168 v1(202.97,30.97) ; CN11.61 174.22,25.11 174.28,25.17 174.28,25.55 173.87,25.95 v1(173.77,25.95) ; CN19.51 171.72,13.67 v1(171.89,13.84) ; CN11.218 215.47,30.34 216.31,29.51 v1(216.44,29.51) ; v1(159.22,26.63) 160.1,26.63 160.22,26.51 160.22,24.05 CN11.5 ; CN11.99 183.72,24.05 183.72,25.57 183.32,25.97 v1(183.22,25.97) ; v1(172.08,64.02) 172.06,63.99 U1.DM47 ; v1(172.08,64.02) 171.77,64.33 U1.DP45 ; v1(172.08,64.02) 172.42,63.68 U1.DL47 ; v1(170.97,17.67) 170.63,17.67 169.97,18.33 CN19.44 ; CN10.27 v1(106.72,67.72) ; CN11.188 207.97,30.75 208.35,30.38 v1(208.49,30.38) 208.66,30.38 208.97,30.69 CN11.192 ; C321.2 202.22,58.89 v1(202.48,58.63) ; v1(185.36,33.62) 185.47,33.5 185.47,32.25 CN11.106 ; 176.97,31.11 176.97,31.09 177.05,31.02 v1(177.05,30.99) ; v1(219.97,63.22) 219.3,63.22 218.48,64.03 217.28,64.03 U1.A46 ; CN19.227 217.72,14.09 218.6,14.97 v1(218.72,14.97) ; v1(169.22,14.39) 169.11,14.39 168.72,14 CN19.39 ; CN19.15 v1(162.72,13.8) ; U1.DU10 169.56,81.75 v1(169.84,81.75) ; CN19.176 204.97,18.76 v1(205.47,18.26) ; CN11.43 169.72,24.05 169.72,26.01 v1(169.22,26.51) ; CN11.27 165.72,24.05 165.72,25.62 165.42,25.93 165.19,25.93 165.16,25.95 165.13,25.95 v1(165.12,25.96) ; 212.22,25.55 212.6,25.93 v1(212.72,25.93) ; CN11.30 166.47,30.97 v1(166.57,30.87) ; v1(169.22,25.93) 169.11,25.93 168.72,25.54 168.72,24.05 CN11.39 ; v1(222.22,25.93) 222.37,25.93 222.72,25.57 222.72,24.05 CN11.247 ; v1(181.22,15.01) 181.36,15.01 182.22,14.15 CN19.93 ; U1.DE29 175.87,72.26 176.16,72.55 v1(176.16,72.62) ; CN11.217 215.22,25.69 ; CN11.57 173.22,24.05 173.22,26.45 172.47,27.2 171.88,27.2 171.87,27.19 171.87,27.18 v1(171.89,27.15) ; v1(165.22,14.39) 165.42,14.39 165.72,14.08 CN19.27 ; v1(177.78,25.98) 177.7,25.98 177.22,25.5 177.22,24.05 CN11.73 ; v1(106.68,71.9) 107.01,72.22 CN10.9 ; v1(164.5,29.8) 164.76,29.8 165.47,30.52 ; v1(169.88,30.96) 169.97,31.06 CN11.44 ; v1(184.19,27.19) 184.3,27.19 185.72,25.76 185.72,24.05 CN11.107 ; v1(164.22,14.39) 164.33,14.39 164.72,13.99 CN19.23 ; v1(106.15,74.31) 106.74,73.72 CN10.3 ; 163.72,14.39 163.15,14.97 v1(162.72,14.97) ; CN11.171 203.72,24.05 203.72,25.68 204.55,26.51 v1(204.72,26.51) ; CN19.106 185.47,18.91 184.18,17.62 v1(183.97,17.62) ; v1(216.19,76.6) 215.86,76.28 U1.C21 U1.B21 216.51,76.28 v1(216.84,76.6) ; v1(224.01,18.26) 223.74,18.26 222.97,19.02 CN19.248 ; CN11.181 206.22,24.05 206.22,25.3 v1(206.18,25.34) ; CN19.14 162.47,19.05 163.27,18.26 v1(163.47,18.26) ; v1(182.98,18.84) 182.81,18.84 182.47,19.18 ; v1(177.78,27.14) 178.07,27.14 178.27,26.95 178.27,25.24 178.22,25.2 CN11.77 ; v1(219.46,30.98) 219.47,30.99 CN11.234 ; CN19.31 166.72,14.09 166.43,14.39 v1(166.22,14.39) ; 209.22,26.01 v1(209.72,26.51) ; CN19.35 167.72,14 168.11,14.39 v1(168.22,14.39) ; CN19.175 204.72,13.51 ; CN10.51 106.88,61.72 106.67,61.93 106.67,63.1 106.66,63.11 v1(106.66,63.14) 106.69,63.14 106.77,63.22 CN10.45 ; CN11.235 219.72,24.05 219.72,25.38 v1(219.69,25.41) ; CN11.239 220.72,24.05 v1(220.72,25.34) ; 209.97,31.16 209.97,30.98 v1(209.99,30.97) ; 209.97,19.62 209.97,18.41 210.77,17.61 v1(211.54,17.61) ; CN19.56 172.97,18.7 ; CN19.181 206.22,13.76 v1(206.18,13.8) ; v1(212.47,31) 212.47,31 ; CN19.77 178.22,15.2 177.83,15.6 v1(177.72,15.6) ; CN19.239 v1(220.72,13.8) ; v1(180.22,15.6) 179.94,15.6 179.19,14.85 179.19,14.1 179.22,14.07 CN19.81 ; v1(161.28,25.34) 161.22,25.29 CN11.9 ; v1(215.48,18.26) 215.1,18.26 214.47,18.88 214.47,19.03 ; CN10.1 108.68,74.22 109,74.54 v1(109,74.83) ; CN19.98 183.46,20.7 183.46,18.08 183.06,17.67 v1(182.98,17.67) ; v1(168.22,25.93) 168.11,25.93 167.72,25.54 167.72,24.05 CN11.35 ; v1(175.72,25.97) 175.89,25.97 176.22,25.63 CN11.69 ; v1(177.72,14.43) 177.55,14.43 177.22,14.1 CN19.73 ; 176.19,78.48 U1.DE15 ; 171.97,19.12 172.26,18.84 v1(172.47,18.84) ; C347.2 186.54,58.89 186.67,58.77 v1(186.67,58.7) ; CN19.36 167.97,18.16 167.47,17.66 v1(166.47,17.66) ; v1(206.97,31) 206.97,31.01 CN11.184 ; v1(174.72,14.43) 174.83,14.43 175.22,14.03 CN19.65 ; v1(174.47,30.31) 174.34,30.31 173.97,30.68 CN11.60 ; 211.22,14.39 212.39,15.55 v1(212.72,15.55) ; CN10.75 106.73,55.72 105.98,56.47 v1(105.98,56.51) ; CN19.168 202.97,19.02 202.21,18.26 v1(201.97,18.26) ; CN19.85 v1(180.22,13.84) ; v1(221.99,29.65) 222.11,29.65 222.97,30.52 CN11.248 ; CN19.90 181.47,19.44 v1(181.48,19.43) ; v1(178.53,17.38) 177.93,17.38 176.97,18.33 176.97,19.57 ; CN19.180 205.97,19.24 205.58,18.84 v1(205.47,18.84) ; 175.97,31.23 v1(175.97,30.97) ; CN19.231 v1(218.72,13.8) ; v1(213.48,18.26) 213.15,18.26 212.47,18.93 ; v1(184.19,14.43) 184.26,14.43 184.72,13.97 CN19.103 ; v1(159.47,18.26) 159.95,18.26 160.47,18.79 ; CN19.251 223.72,13.99 v1(223.28,14.44) ; U1.DF22 174.9,75.27 174.8,75.17 174.8,75.15 174.81,75.14 174.82,75.14 v1(174.88,75.2) ; v1(205.47,29.8) 204.97,30.3 CN11.176 ; CN11.231 218.72,24.05 218.72,26.5 v1(219.79,27.57) 220.5,28.28 223.32,28.28 223.97,28.93 CN11.252 ; CN19.30 v1(166.47,19.43) ; CN19.60 v1(173.97,22.07) ; 175.97,19.69 v1(175.97,19.43) ; v1(179.23,25.35) 179.22,25.35 179.22,24.05 CN11.81 ; U1.DR49 170.84,62.37 170.52,62.04 v1(170.52,61.98) 170.19,62.31 U1.DT49 ; 217.51,19.06 218.32,18.26 v1(218.48,18.26) ; 209.22,14.47 v1(209.72,14.97) ; CN11.56 172.97,30.96 ; U1.DW2 U1.DV2 U1.DW1 v1(168.21,86.25) U1.DW2
  TOP w0.3: U1.H17 212.81,78.43 U1.J16 211.62,78.43 v1(211.57,78.48) ; U1.AF47 v1(204.47,64.06)
  TOP w0.305: R857.2 164.66,63.15 v1(164.98,63.46) ; v1(77.51,75.81) 77.51,75.73 77.44,75.65 R814.1 ; v1(163.1,61.05) 163.42,60.72 164.53,60.72 R387.2 ; R73.2 164.77,80.61 v1(164.73,80.65) ; R77.1 220.18,61.88 R75.1 220.2,61 R76.1 221.64,60.99 v1(222.06,60.57) ; CN22.1 141.63,108.61 141.82,108.8 v1(141.82,110.68) ; Q41.2 v1(36.66,55.3) ; v1(213.15,68.51) v1(212.5,68.51) 212.5,68.58 U1.J36 213.15,68.63 213.15,68.58 ; v1(213.15,68.51) v1(213.8,68.51) ; v1(213.15,68.51) 213.15,68.58 ; R384.2 171.1,55.4 v1(170.55,54.85) ; C28.2 83.96,93.56 83.99,93.59 v1(84.29,93.59) ; C484.2 37.38,82.8 v1(37.38,82.22) 37.25,82.09 C485.1 ; D59.P v1(8.75,113.44) ; v1(50.4,71.74) 50.1,71.43 Q13.2 ; CN22.19 139.73,104.11 139.57,104.28 139.12,104.28 v1(138.96,104.11) ; 213.15,68.58 U1.H36 ; C6126.2 218.91,71.88 217.64,71.88 v1(217.49,72.03) ; v1(44.25,78.71) 44.1,78.56 R372.2 ; 213.93,59.44 214.05,59.44 v1(214.41,59.08) ; v1(230.58,54.17) 230.58,54.2 230.75,54.37 U32.3 ; v1(81.05,70) 81.05,69.97 81.04,69.95 Q79.2 81.37,68.61 R803.1 ; R163.1 165.37,71.73 R162.1 ; R163.1 165.1,71.75 164.89,71.95 v1(164.89,71.96) ; R163.1 165.39,72.55 R679.2 ; UC1.2 v1(164.61,68.91) ; v1(111.72,114.99) 111.6,115.11 SW1.E1 ; U38.1 60.94,111.02 62.11,109.86 v1(62.11,109.55) ; CN11.230 218.47,29.69 217.81,29.02 v1(217.55,29.02) ; v1(229.82,16.42) 230.29,16.88 Q72.2 ; U55.5 146.17,71.38 v1(145.98,71.18) C396.1 ; R148.2 198.12,90.4 v1(197.94,90.58) ; v1(233.66,52.2) 233.64,52.22 C449.1 ; C341.2 59.09,76.17 v1(59.19,76.27) ; R208.2 145.8,101.35 v1(145.8,101.36) ; 162.27,56.7 161.86,56.7 161.8,56.76 v1(161.76,56.76) ; 162.27,56.7 R324.2 ; 162.27,56.7 162.27,57.47 R108.2 ; X1.4 v1(167.09,87.81) 167.09,87.15 166.59,86.65 166.59,85.8 C13.2 v1(165.89,84.52) ; v1(131.93,104.57) 132.13,104.36 CN22.18 ; v1(230.44,47) 230.56,47 U33.3 ; v1(57.69,102.81) CN3.2 ; CN22.E1 140.6,109.75 141.27,110.43 v1(141.27,110.67) ; v1(215.48,18.26) 215.57,18.17 215.74,18.17 216.55,18.99 ; R180.1 v1(157.84,75.13) ; C430.1 38.18,82.01 C429.1 v1(38.8,82.65) ; C6135.2 163.17,111.11 v1(162.91,111.36) 162.62,111.66 PR57.1 ; CN19.209 213.22,11.08 213.51,10.8 213.94,10.8 214.22,11.09 CN19.213 ; CN3.8 58.02,99.81 v1(58.71,100.51) ; CN11.206 212.47,33.33 212.24,33.56 211.64,33.56 211.47,33.39 CN11.202 ; R405.2 v1(158.53,80.22) 158.22,79.91 R874.1 ; D54.P v1(13.43,93.42) ; C281.1 161,88.91 v1(161.29,88.91) ; C225.1 92.72,72.45 92.94,72.45 v1(92.98,72.4) ; 162.95,88.81 162.95,86.78 C11.2 v1(164.63,84.58) ; 162.95,88.81 v1(162.94,88.82) ; 162.95,88.81 163.64,89.51 X1.2 164.12,89.51 164.97,90.35 166.95,90.35 167.99,89.31 R85.2 168.78,89 R20.2 v1(168.79,89.54) ; C340.1 v1(41.7,59.87) ; C457.2 v1(24.8,77.42) ; CN19.230 218.47,19.44 v1(218.48,19.43) ; CN11.27 165.72,22.82 165.53,22.62 164.94,22.62 164.72,22.84 CN11.23 ; U13.3 v1(218.15,87.93) ; v1(23.71,87.51) 23.71,87.18 C339.2 ; v1(130.1,105.35) 130.05,105.4 R415.2 ; v1(217.86,77.96) 219.56,77.96 R851.1 220.11,79.29 R852.1 220.11,80.06 R841.2 R842.2 220.12,80.9 219.7,81.32 217.7,81.32 217.48,81.1 v1(217.47,81.11) ; CN22.63 139.58,93.11 v1(139.56,93.1) ; C431.1 v1(36.68,79.78) ; v1(57.7,107.13) 58.58,108.01 C230.1 ; 174.58,79.26 174.58,79.61 U1.DG13 U1.DG12 ; Q31.2 84.22,106.56 v1(83.47,105.8) R811.1 ; v1(158.28,87.99) 158.25,88.02 158.25,88.07 158.48,88.3 U21.5 ; v1(84.31,91.33) 83.44,91.33 83.19,91.58 C29.2 ; R568.1 v1(19.66,40.39) ; R204.2 C349.1 ; v1(113.56,58.86) 113.69,58.72 Q40.2 ; C488.1 38.12,80.18 v1(37.89,80.41) 37.39,80.91 C487.1 ; v1(217.68,25.41) 217.72,25.36 CN11.227 ; v1(138.91,105.84) 138.96,105.79 139.16,105.79 139.34,105.61 CN22.13 ; R865.1 173.57,56.08 173.57,56.74 v1(173.61,56.77) 173.61,58.22 R382.2 ; C331.1 R36.2 125.85,76.44 v1(125.99,76.31) ; CN22.57 139.28,94.61 139,94.89 v1(138.83,94.89) 139.19,95.24 139.19,95.88 139.42,96.11 CN22.51 ; C461.1 v1(25.12,72.72) ; D60.P v1(8.72,110.38) ; R870.1 165.37,81.61 165.37,81.99 v1(165.48,82.09) ; C640.1 v1(234.02,15.89) ; R159.2 v1(194.96,90.61) ; v1(189.62,58.82) 189.75,58.95 C334.2 ; v1(59.91,86.48) 60.3,86.48 60.55,86.23 D26.1 ; v1(2.05,98.3) 2.05,98.35 2.06,98.37 D57.P ; U5.3 v1(151.49,61.29) ; v1(142.34,110.68) 142.34,108.15 142.16,107.72 141.56,107.11 CN22.7 ; Q12.2 v1(52.46,71.43) ; R381.2 v1(157.68,67.57) 157.85,67.74 R875.1 ; v1(62.08,106.89) 62.24,107.05 C231.1 ; R567.1 v1(19.49,41.62) ; R111.1 v1(157.27,77.38) ; v1(23.35,85.22) 23.77,85.64 C279.1 ; CN12.5 v1(147.26,46.75) ; v1(57.91,101.31) CN3.5 ; v1(222.22,25.93) 222.06,25.93 221.69,25.56 221.69,25.13 221.72,25.09 CN11.243 ; v1(150.73,101.07) 150.81,100.99 C350.1 ; C232.1 R190.2 v1(62.45,91.04) ; v1(71.22,76.03) 71.22,76.03 71.2,76.05 70.56,75.4 C6039.1 ; C6041.1 76.99,75.92 v1(76.99,75.83) ; D62.P v1(228.19,113.71) ; CN10.71 106.9,56.72 v1(106.68,56.51) 106.97,56.22 CN10.73 109.79,56.22 R535.2 ; v1(150.62,113.51) 150.49,113.65 D65.P ; Q36.2 122.11,111.79 121.54,111.22 v1(121.29,111.22) ; v1(95.82,55.56) 96.46,54.92 C88.1 ; CN10.57 108.34,60.22 108.47,60.09 v1(108.47,59.64) ; R213.1 127.94,104.42 127.9,104.46 v1(127.9,104.5) ; R1398.2 219.98,89.19 v1(220.37,89.58) ; v1(230.3,21.76) 230.62,21.43 C642.2 ; v1(233.1,42.8) 232.76,43.14 C491.2 232.59,43.14 R518.2 ; v1(164.67,91.9) 164.28,91.51 C357.2 ; v1(74.22,75.95) 73.68,75.4 C6040.1 ; R830.2 152.57,60.96 v1(152.57,61.29) ; C462.1 24.19,75.72 v1(24.2,75.71) ; C26.1 91.04,90.74 v1(91.19,90.59) 91.45,90.59 C25.2 C30.1 ; v1(104.95,114.36) 104.95,113.41 SW1.2 ; D49.8 v1(55.67,88.57) ; C352.1 147.38,101.13 v1(147.14,101.36) ; v1(13.49,102.47) D56.P ; C486.2 37.07,76.67 37.02,76.61 v1(37.02,76.54) ; R569.1 v1(19.67,39.08) ; U40.3 95.73,61.98 v1(95.86,61.85) ; v1(34.15,62.89) 34.15,63.22 34.27,63.33 C432.1 ; CN22.69 v1(139.59,91.61) ; v1(30.57,91.37) R395.2 C478.1 ; R281.1 128.02,92.57 127.8,92.35 v1(127.8,92.31) ; R570.2 v1(19.64,37.79) ; SW1.E2 v1(103.62,114.16) ; v1(46.95,70.06) 46.96,70.07 47.59,70.07 R119.2 ; v1(81.25,71.25) 81.04,71.46 Q77.2 81.53,72.36 R802.1 ; Q44.2 35.56,60.93 v1(35.69,61.06) ; R892.1 212.89,91.36 v1(212.89,91.36) ; v1(133.67,60.33) 133.67,61.08 ; 133.67,61.08 U49.4 ; 133.67,61.08 U49_1.4 132.81,61.08 ; R188.2 v1(142.62,78.04) ; v1(57.91,98.31) CN3.11 ; CN12.4 v1(146.26,46.76) ; v1(138.15,68.05) C878.1 ; U23.3 34.52,65.94 v1(34.15,65.57) ; v1(146.12,47.97) D32.P ; PR30.1 v1(159.84,80.15) 160.02,80.33 R868.2 ; v1(157.94,87.64) 157.92,87.66 157.52,87.66 C295.1 ; v1(105.28,54.61) 105.31,54.58 CN10.E2 ; CN6.E2 v2(4.27,110.1) ; v1(125.27,93.88) 125.27,93.95 125.87,94.55 R276.2 ; CN11.172 203.97,30.97 ; CN22.45 139.5,97.61 139.36,97.47 v1(139.36,97.33) ; CN11.22 164.47,33.38 164.23,33.62 163.69,33.62 163.47,33.41 CN11.18 ; C877.1 v1(141.37,68.05) ; D33.P v1(143.42,47.95) ; v1(151.18,103.05) 150.47,102.34 PC51.1 ; v1(232.3,26.22) C641.1 ; C27.2 v1(84.61,87.56) ; v1(145.47,71.28) 145.81,71.61 C399.1 ; PR56.1 v1(162.97,78.33) ; CN6.E1 v2(4.27,113.48) ; v1(52.69,90.67) D48.8 ; C6130.1 v1(154.95,92.92) ; C342.2 v1(38.98,60.77) ; v1(228.62,110.41) D61.P
  TOP w0.406: CN10.E1 106.78,75.02 v1(106.78,74.36) ; C6038.1 66.84,76.03 67.28,75.59 v1(67.69,75.59) ; C6124.2 227.52,109.74 D61.P ; U34.3 v1(41.28,62.19) ; v1(35.72,75.47) 35.77,75.52 C482.2 36.46,75.96 C483.1 ; C532.1 52.56,31.96 v1(52.54,31.98) ; C6123.2 v1(227.06,115.42)
  TOP w0.504: C328.2 v1(194.77,58.71) ; C348.2 184.56,59.33 v1(184.08,58.86) ; C329.2 192.13,59.16 192.13,59.16 192.13,58.69 v1(192.18,58.65) ; v1(212.32,57.53) 212.32,57.75 C318.2 ; v1(197.43,58.73) 197.31,58.85 C327.2
  TOP w0.508: v1(142.78,80.65) R220.1 ; PC69.2 v1(97.21,88.14) ; v2(94.93,71.55) 94.38,72.09 C263.1 ; C6122.2 v1(10.13,114.19) ; CN21.4 v2(36.02,29.73) ; CN21.28 v1(44.15,20.73) ; PR50.1 181.32,111.61 v1(181.2,111.73) ; CN21.31 v1(44.14,23.73) ; PR22.1 190.24,115.14 v1(190.4,115.29) ; v1(230.34,32.26) 230.38,32.3 CN13.4 ; CN21.12 v2(35.93,21.73) ; Q85.2 230.7,102.43 231.26,102.99 v2(232.34,102.99) ; CN21.25 v1(44.11,17.73) ; CP20.2 205.34,103 205.34,101.84 206.21,100.98 PC38.1 ; v1(18.03,110.94) U11.2 ; CN21.1 v2(36.04,32.73) ; CN21.37 v1(41.94,29.73) ; C6121.2 v1(8.74,109.58) ; v1(39.59,109.32) U22.2 ; CN21.34 v1(41.93,26.73) ; CN21.E1 v2(38.84,35.95) ; PR80.1 v1(213.75,114.92) ; C545.1 v1(56.03,32.85) ; CN21.7 v2(35.91,26.73) ; CN21.E2 v1(40.22,11.73) ; PC7.1 v1(195.71,114.39) ; CN21.40 v1(41.93,32.73) ; v1(178.67,103.01) 178.22,103.01 178.12,102.91 178.09,102.91 PC20.1 ; U29.2 v1(53.96,111.1)
  TOP w0.61: CN21.21 v2(41.48,13.73) ; CN21.22 v2(41.48,14.73) ; CN21.19 v2(35.92,14.73) ; CN21.20 v2(35.78,13.73)
  TOP w0.762: FB22.1 v2(17.34,85.88)
  ART03 w0.203: v1(31.72,74.65) 31.74,74.64 32.47,74.64 34.38,76.55 34.38,80.87 35.8,82.29 35.8,87.11 34.7,88.22 34.7,108 39.12,112.43 75.55,112.43 77.06,110.92 82.05,110.92 84.06,112.93 88.42,112.93 89.47,111.88 110.44,111.88 111.23,112.68 124.49,112.68 125.14,113.32 126.41,113.32 126.77,112.96 v2(126.77,112.87) ; 32.87,87.78 33.14,88.06 33.14,106.48 32.9,106.72 32.9,109.99 37.13,114.21 76.26,114.21 77.87,112.6 81.19,112.6 83.31,114.72 89.42,114.72 90.61,113.53 109.73,113.53 110.73,114.53 123.38,114.53 123.9,115.06 134.99,115.06 MH4.1 137.62,114 138.29,114.67 148.81,114.67 149.41,115.27 ; 32.87,87.78 34.09,86.56 34.09,82.94 v1(32.51,81.35) 32.52,81.34 32.52,79.9 v1(32.5,79.88) 32.52,79.86 v1(32.52,78.28) ; 32.87,87.78 29.56,91.09 27.23,91.09 23.7,94.62 23.7,105.31 18.08,110.94 v1(18.03,110.94) 16.18,112.78 11.67,112.78 11.07,112.19 11.07,111.47 11.61,110.93 15.41,110.93 21.79,104.55 21.79,94.1 26.41,89.48 28.78,89.48 32.42,85.83 32.42,83.77 30.51,81.86 v1(29.71,81.86) ; v2(185.33,113.22) 185.01,113.54 181.31,113.54 180.77,114.09 MH2.1 178.61,114.67 153.33,114.67 152.81,115.19 ; v1(216.81,102.14) 216.74,102.22 216.28,102.22 214.62,100.55 214.62,98.59 216.75,96.46 223.57,96.46 225.24,94.79 225.24,89.91 222.42,87.09 222.42,86.08 220.99,84.66 220.99,81.12 218.97,79.1 218.97,77.69 218.48,77.19 217.26,77.19 216.84,76.77 v1(216.84,76.6) ; v2(128.21,112.87) 128.26,112.83 128.47,112.83 129.1,113.45 132.12,113.45 134.39,111.18 137.24,111.18 139.13,113.07 176.24,113.07 178.07,111.24 181.33,111.24 181.94,111.85 183.93,111.85 184.58,111.2 194.98,111.2 196.91,109.27 217.91,109.27 221.99,113.36 233.02,113.36 v1(233.16,113.22)
  ART03 w0.305: v1(159.22,26.63) 158.42,26.63 157.71,25.91 157.71,19.61 159.06,18.26 v1(159.47,18.26) ; v1(184.21,7.25) 179.53,11.94 161.13,11.94 159.22,13.84 v1(159.22,14.08) ; v1(159.47,29.8) 159.08,29.8 158.38,30.5 158.38,31.93 159.24,32.78 159.24,35.5 175.95,52.22 179.74,52.22 181.23,53.7 181.23,59.41 v1(182.79,60.97) 182.79,61.19 v1(183.34,61.74) 184.5,62.9 v1(184.5,63.99) 184.5,66.46 v1(185.14,67.1)
  ART06 w0.305: v1(180.78,61.85) 180.78,62.68 182.04,63.94 v1(182.04,64.12) ; v1(159.47,30.97) 158.52,31.91 158.52,33.22 159.27,33.97 159.27,39.17 v1(161.56,41.46) 173.11,53 173.11,55.1 175.75,57.74 176.22,57.74 179.51,61.03 v1(179.52,61.03)
  BOTTOM w0.102: v1(189.46,64.06) 189.67,63.86 189.67,63.64
  BOTTOM w0.203: R910.1 158.29,92.38 v1(158.85,92.93) ; PR59.1 218.19,101.61 217.97,101.83 217.33,101.83 217.02,102.14 v1(216.81,102.14) ; Q88.2 144.91,94.82 145.82,95.73 148.71,95.73 v1(151.1,93.34) ; 114.19,54.14 114.99,53.34 U2.1 ; 114.19,54.14 U2.E1 114.19,54.22 ; 114.19,54.14 U2.3 ; C6154.2 51.32,99.13 v1(51.45,99.26) ; v1(196.12,65.83) v1(196.12,66.46) v1(196.12,67.1) v1(196.12,67.73) ; U10.3 126.53,95.73 126.8,96 126.8,96.65 v1(126.9,96.75) ; v1(190.63,66.46) v1(190.63,67.1) ; PR21.1 223.12,97.63 v1(223.08,97.67) ; v1(68.01,21.77) 67.98,21.74 R592.2 ; v1(57.8,62.08) 57.58,62.31 R355.2 57.58,62.71 ; v1(164.85,96.61) 165.25,96.21 U6.14 ; D16.1 58.31,100.11 v1(58.71,100.51) ; U42.3 v1(56.43,27.18) ; v1(234.16,16.94) 234.09,17.01 C6159.2 ; v1(225.09,97.69) 225.15,97.64 PR24.1 ; v1(201.65,14.39) 202.1,14.84 C168.1 ; v1(40.84,97.75) D37.P ; v1(52.23,76.31) 52.16,76.38 U9.91 ; R909.2 157.68,74.98 v1(157.84,75.13) ; v1(170.75,60.51) 170.88,60.64 C47.2 172.21,60.64 172.78,61.21 174.77,61.21 175.02,60.96 175.02,57.42 174.81,57.21 172.65,57.21 C46.2 170.76,57.92 170.27,58.41 v1(170.27,58.73) ; PR26.1 224.16,97.62 v1(224.09,97.68) ; U9.49 v1(39.12,70.05) ; v1(153.19,82.32) 153.14,82.32 153.12,82.3 153.1,82.3 153.09,82.29 153.09,81.56 U56.3 ; C83.1 54.17,103.11 54.04,103.24 ; v1(56.33,60.86) 56.2,60.74 R356.1 ; v1(157.41,89.34) 157.02,88.95 R902.1 ; v1(43.76,63.16) U9.27 ; PC59.2 221.44,109.76 v1(221.76,110.08) ; U42.17 54.13,21.59 53.78,21.24 v1(53.78,20.59) 53.73,20.64 U42.18 ; v1(19.51,102.63) D22.P ; 114.19,54.22 114.23,54.26 114.33,54.26 114.59,54.52 U2.14 ; 114.19,54.22 v1(114.19,54.3) ; U9.104 v1(54.73,73.25) ; v1(187.89,65.83) v1(187.89,66.46) ; v1(218.97,55.56) 218.9,55.63 R44.2 ; U42.28 v1(49.73,22.64) ; U9.75 45.76,78.53 45.88,78.65 v1(45.88,78.76) ; PR107.1 v1(44.91,12.35) ; v1(40.77,100.51) D36.P ; v2(53,103.59) 53.28,103.32 R485.2 ; v1(19.41,105.37) D21.P ; PR120.2 v1(34.71,15.22)
  BOTTOM w0.254: X2.2 61.63,72.19 61.62,72.2 ; v1(185.14,68.37) v1(183.98,68.37) v1(183.06,68.37) v1(182.15,68.37) v1(181.23,68.37) v1(180.32,68.37) ; 61.62,72.2 61.62,71.07 v1(61.64,71.06) 61.62,71.05 61.62,69.18 61.95,68.85 64.26,68.85 ; 61.62,72.2 61.62,72.64 62.1,73.12 65.08,73.12 65.21,73 65.21,72.07 v1(65.63,71.65) C1.2 ; v1(179.4,69.64) v1(179.4,69) ; 64.26,68.85 X2.4 ; 64.26,68.85 64.27,68.84 64.6,68.84 v1(64.63,68.87) 64.66,68.91 64.78,68.91 65.65,69.77 v1(65.65,70.43) C413.2 ; R74.2 208.74,68.98 208.96,69.2 211.39,69.2 C274.2 211.68,68.68 v1(211.85,68.51) ; v1(213.59,72.03) v1(214.24,72.03) v1(214.89,72.03) v1(215.54,72.03) v1(216.19,72.03) v1(216.84,72.03) v1(217.49,72.03)
  BOTTOM w0.305: U37.3 25.28,46.5 v1(25.75,46.97) ; v1(185.14,82.38) 185.26,82.27 C125.2 ; R581.2 v1(62.69,29.44) ; Q10.2 v1(153.06,51.09) ; C411.2 v1(211.27,9.95) ; C6064.2 100.28,108.5 C3218.1 99.18,107.98 D58.2 97.16,107.98 96.47,108.68 Q30.2 96.47,114.69 v1(96.34,114.82) ; v1(201.97,18.26) 202.43,18.26 R285.2 ; C428.2 v1(75,75.95) ; v1(177.78,25.98) 178.16,25.98 C903.1 ; C524.1 126.16,53.84 v1(126.34,54.02) ; C531.1 v1(52.54,31.98) ; v1(75.44,60.71) 75.5,60.66 C191.1 ; v1(215.56,67.46) 215.19,67.1 R87.1 ; v1(212.73,80.33) 212.98,80.09 R848.1 ; v1(28.08,53.5) 28.08,53.23 U35.3 ; v1(177.65,93.39) 177.96,93.7 PC64.2 ; C224.1 118.12,68.72 v1(117.95,68.55) ; v1(174.47,29.7) 174.6,29.83 C901.1 ; v1(224.01,18.26) 223.94,18.33 R290.2 ; CN14.35 224.75,50.2 225.09,50.54 v1(225.09,50.82) ; PC18.1 228.77,106.42 v1(228.15,106.42) ; R383.2 170.74,62.2 v1(170.52,61.98) ; C173.1 173.09,14.43 v1(173.72,14.43) ; v1(226.72,92.56) 226.72,92.42 226.35,92.06 C6137.2 ; R94.2 165.96,60.34 v1(166.36,59.94) ; C157.1 181.71,21.83 v1(181.35,22.19) ; v1(183.06,65.83) 183.1,65.79 R80.2 183.48,65.14 183.1,64.76 R279.1 ; R198.1 v1(72.77,64.76) ; v1(171.56,76.71) 171.56,77.08 R110.2 ; C892.1 217.86,20.05 v1(218.48,19.43) ; R816.1 116.63,70.24 Q86.2 117.28,71.42 v1(117.64,71.78) ; R736.2 201.4,28.35 200.9,28.35 200.8,28.25 v1(200.44,28.25) ; v1(163.17,101.81) 163.16,101.81 162.82,101.48 C6134.2 ; C300.1 202.02,64.11 v1(202.02,64.12) ; v1(168.42,61.87) 168.88,61.41 R377.2 ; v1(75.78,75.95) 75.8,75.93 C425.2 ; C421.2 69.91,65.23 v1(70.32,64.82) ; v1(145.3,62.07) 145.18,61.94 Q78.2 ; C434.2 71.52,75.69 v1(71.8,75.97) ; v1(32.58,51.61) C507.1 ; R246.2 C146.1 v1(122.87,87.13) ; R326.1 v1(164.67,91.9) ; R542.2 v1(25.99,54.05) ; CN2.E2 130.91,61.19 128.71,63.39 v2(126.91,63.39) 127.44,63.92 Q81.2 ; v1(47.08,16.63) 47.08,17.48 C547.2 ; CN14.47 224.85,55 225.13,54.71 v1(225.13,53.19) 225.13,52.87 224.86,52.6 CN14.41 ; v1(25.48,50.96) 25.43,51.01 R556.1 ; v1(211.62,82.15) 211.7,82.07 R178.2 211.99,80.65 R849.1 ; v1(210.7,26.04) 211.07,26.04 211.49,26.45 C888.1 210.82,27.34 v1(210.66,27.34) ; v1(59.1,65.34) 58.99,65.23 R335.1 ; 113.4,57.86 C195.1 113.94,57.86 113.94,57.86 R55.1 114.36,58.04 114.36,58.74 v1(114.14,58.97) ; 113.4,57.86 R56.2 ; 113.4,57.86 113.76,58.23 113.76,58.65 v1(113.56,58.86) ; C885.1 202.91,31.03 v1(202.97,30.97) ; R566.2 R572.1 R571.2 23.16,53.19 v1(23.16,53.19) ; v1(41.7,59.87) 41.57,59.73 R345.2 ; v1(178.48,68.97) 177.88,68.37 C198.1 ; v1(208.5,91.62) 208.87,91.26 R153.1 ; C156.1 203.34,20.24 R193.1 203.35,20.06 v1(203.98,19.43) ; C424.2 74.23,75.94 v1(74.22,75.95) ; C719.1 219.62,76.59 v1(219.63,76.59) ; v1(217.83,105.35) PR6.2 ; v1(220.72,13.8) 221.29,13.8 C162.1 221.53,13.98 221.94,14.39 v1(222.22,14.39) ; C897.1 201.75,26.7 v1(201.83,26.62) ; v1(50.65,18.41) 50.7,18.46 R598.1 ; v1(172.08,64.02) 171.67,63.6 R839.2 ; C534.1 65.99,25.69 66.66,26.36 v1(66.94,26.36) 66.89,26.41 U57.3 ; R548.1 v1(45.24,57.94) R840.1 ; R680.2 169.44,73.21 v1(169.9,73.67) 169.99,73.59 R908.2 170.46,73.48 171.12,73.48 v1(171.62,72.98) ; R493.1 67.97,75.88 v1(67.69,75.59) ; R81.1 217.01,61.94 v1(217.13,62.07) ; PC58.2 219.37,107.77 219.24,107.9 v1(219.12,107.9) ; v1(164.22,25.93) 164.02,25.93 163.58,25.48 C890.1 163.32,25.34 v1(162.72,25.34) ; v1(29.1,45.22) R532.1 ; C902.1 199.47,23.56 C889.1 200.31,23.02 v1(200.69,22.64) ; v1(224.01,19.43) 223.48,19.43 R289.2 ; v1(107.25,59.76) 106.66,59.76 106.23,59.33 U50.3 ; 213.04,91.21 213.09,91.15 R885.1 ; 213.04,91.21 v1(212.89,91.36) ; 213.04,91.21 R882.1 ; v1(112.33,51.39) 112.89,50.82 R121.2 113.15,50.51 C131.1 ; C388.1 215.56,83.44 v1(215.7,83.58) 215.89,83.76 C6136.2 ; D4.1 v1(62.86,94.94) ; C401.1 118.43,74.21 v1(118.25,74.03) ; C6132.2 188.79,84.94 v1(188.8,84.95) ; C161.1 176.31,14.43 v1(175.72,14.43) ; C164.1 184.92,19.36 184.4,18.84 v1(183.98,18.84) ; v1(169.95,65.77) 169.85,65.88 R850.1 ; v1(52.37,18.59) 52.46,18.68 C549.1 C550.1 ; C200.2 166.31,81.25 v1(165.48,82.09) ; v1(204.13,104.24) 204.13,104.25 PU3.6 ; R104.1 v1(169.02,58.3) 169.02,57.89 R19.1 ; C289.2 186.81,58.84 v1(186.67,58.7) ; C891.1 221.37,24.69 v1(220.72,25.34) ; R99.1 177.74,71.21 v1(177.68,71.27) ; C715.1 v1(219.58,74.66) ; C898.1 179.42,30.9 v1(179.48,30.97) ; C360.1 172.02,67.66 170.57,67.66 v1(169.87,68.36) ; C244.2 179.11,84.82 v1(179.23,84.69) ; C525.2 124.3,53.61 v1(124.09,53.82) ; R604.1 49.9,18.48 v1(49.99,18.39) ; U44.1 52.86,15.42 v1(52.21,14.77) 52.82,14.15 U44.2 ; C170.1 201.02,18.57 v1(200.93,18.66) 200.7,18.88 C142.1 ; R926.1 54.43,96.92 v1(54.35,96.84) ; v1(229,98.65) 228.86,98.65 228.58,98.93 PR93.1 ; C895.1 191.28,29.78 v1(191.58,29.48) ; v1(70.89,64.75) 70.67,64.53 C420.1 ; v1(174.29,84.65) 174.29,84.64 PC65.2 ; v1(47.55,18.97) R607.1 R608.1 ; C893.1 174.12,29.97 v1(174.47,30.31) ; v1(103.9,55.51) 103.93,55.54 Q83.2 ; C9.2 49.87,58.72 v1(50.14,58.72) ; PC61.2 228.29,112.09 228.94,112.74 v1(228.94,113.19) ; v1(161.47,19.45) 161.42,19.51 C174.1 ; R788.1 119.52,63.19 v1(119.67,63.04) ; v1(59.76,9.87) 59.27,9.38 R582.2 ; v1(210.62,9.93) 210.62,9.89 211.05,9.47 C214.2 ; R737.2 218.38,26.88 218.21,26.71 217.74,26.71 v1(217.68,26.65) ; v1(184.19,14.43) 185.23,14.43 C166.1 ; C353.2 182.03,57.61 183.15,56.49 183.15,55.1 183.63,54.61 v1(183.96,54.61) ; C169.1 182.88,18.74 v1(182.98,18.84) ; C21.1 168.13,96.35 v1(167.57,95.79) ; C526.1 216.37,101.46 PC57.2 216.81,101.67 v1(216.81,102.14) ; v1(173.13,84.03) 172.91,83.8 R612.1 ; CN14.50 v1(233.84,56.2) ; v1(35.07,46.47) C509.1 ; v1(69.7,75.86) 69.7,74.98 C418.2 ; R350.2 56.81,83.51 58.71,83.51 v1(59.73,84.54) ; v1(168.22,14.39) 168.15,14.31 167.26,14.31 C165.1 166.95,14.32 166.29,14.32 v1(166.22,14.39) ; v1(171.65,65.75) 171.52,65.87 R226.2 ; C171.1 175.54,19.25 175.72,19.43 v1(175.97,19.43) ; v1(225.09,47) CN14.27 ; v1(77.41,62.88) 77.41,63.11 78.07,63.77 U18.3 ; v1(46.04,80.58) 45.75,80.28 C70.2 ; v1(191.54,28.52) 191.52,28.5 C900.1 ; C417.2 v1(77.69,71.27) ; R888.1 208.08,88.09 v1(208.01,88.01) ; C433.2 C426.2 66.17,73.57 66.73,74.12 v1(66.76,74.12) ; R543.1 v1(39.52,46.89) ; v1(217.47,81.11) 217.49,81.12 C727.1 ; C238.2 181.62,84.8 v1(181.73,84.69) ; v1(179.4,69) 179.23,68.83 R282.1 ; v1(24.26,98.22) D27.P ; Q69.2 115.82,65.92 v1(115.57,66.18) ; Q7.2 v1(154.41,47.28) ; C267.2 208.26,79.12 v1(208.26,79.46) ; v1(164.61,68.91) 165.09,69.39 C136.1 165.89,69.38 C308.1 ; v1(217.73,85.1) 218.18,84.65 R224.1 ; v1(169.22,25.93) 169.45,26.16 C896.1 ; v1(120.44,66.62) 120.45,66.63 Q71.2 ; R318.1 v1(165.54,91.95) ; v1(53.08,10.89) 53.49,11.31 U44.4 U44.3 ; v1(185.36,33.62) 185.11,33.37 C887.1 ; v1(59.89,27.92) 60.08,27.73 C543.1 C542.1 v1(58.59,27.34) C541.1 ; C894.1 161.66,31.22 v1(161.41,30.97) ; U39.5 v1(55.96,10.23) ; Q11.2 53.03,86.25 v1(54.05,87.28) ; v1(150.46,87.9) 150.31,88.06 Q84.2 ; C15.2 167.11,57.67 v1(167.24,57.8) ; PR83.2 211.91,78.15 v1(211.57,78.48) ; PR115.1 226.04,110.09 PC15.2 ; v1(172.47,18.26) 172.38,18.35 C167.1 ; v1(45.24,85.16) 44.85,85.54 Q48.2 ; v1(160.88,55.9) 161.03,55.75 U54.3 ; v1(6.44,104.94) 6.43,104.94 D53.P ; R388.2 177.57,67.58 v1(177.57,67.73) ; v1(189.58,33.59) 189.37,33.37 C899.1 ; v1(164.89,71.96) 164.89,71.95 165.25,71.59 C192.1 165.83,72.36 R379.1 ; v1(181.22,15.01) 181.6,15.01 C176.1 ; R339.2 38.62,59.13 v1(38.68,59.19) ; 208.93,81.13 208.93,80.25 209.25,79.94 C266.2 210.73,80.32 v1(210.9,80.32) ; v1(42.89,57.83) 43.11,58.06 R207.1 ; v1(77.51,73.46) 77.7,73.27 C416.2 ; Q49.2 39.04,85.55 38.72,85.23 v1(38.72,85.16) ; Q76.2 118.03,78.48 v1(117.81,78.7) ; R7.2 172.26,81.59 v1(172.85,82.18) ; v1(225.09,47.8) CN14.29 ; v1(221.78,99.06) 222.13,98.71 PC13.2 222.12,98.45 PR77.1 ; C535.1 59.13,22.95 v1(59.1,22.95) ; v1(75.41,66.44) R269.2 ; C438.2 71.45,65.47 C437.1 v1(71.45,64.78) ; R738.2 222.91,27.29 222.92,27.28 ; C172.1 168.3,19.43 v1(168.97,19.43) ; C517.2 v1(60.65,13.24) ; v1(225.16,44.62) 225.13,44.6 CN14.21 ; C8.1 v1(48.41,58) ; v1(164.2,101.69) 164.18,101.69 164.15,101.66 164.15,100.93 163.93,100.71 163.83,100.71 163.68,100.56 163.68,100.46 PR69.2 ; v1(73.2,60.93) 72.92,60.66 U4.2 ; CN14.40 v1(233.66,52.2) ; v1(195.44,17.55) 195.51,17.48 C175.1 ; v1(163.47,53.76) 163.47,53.6 163.18,53.31 C128.1 ; C14.2 167.92,65.57 v1(167.95,65.53) ; C540.1 v1(46.22,26.39) ; v1(24.26,100.99) D28.P ; C546.1 v1(47.61,16.13) ; D52.P v1(5.37,94.03) ; R531.2 28.3,45.21 v1(28.3,45.21) ; C520.1 v1(56.39,9.83) ; v1(233.21,49.87) 233.13,49.8 CN14.34 ; v1(70.2,62.89) C415.2 ; R539.1 v1(36.8,53.22) ; R411.2 v1(62.77,12.12) ; C518.1 v1(55.53,9.95) ; v1(214.56,14.39) 214.07,14.39 213.9,14.21 C163.1 213.52,14.39 v1(212.72,14.39) ; Q4.2 105.72,52.14 v1(105.76,52.1) ; R546.1 32.79,54.42 v1(32.86,54.49)
  BOTTOM w0.406: PC42.2 217.48,105.7 v1(217.83,105.35) ; C512.1 33.81,47.44 v1(33.99,47.26) ; v1(213.59,72.03) 212.86,72.03 C717.1 212.74,71.91 C22.2 ; U43.3 v1(39.46,14.53) ; R538.1 v1(38.58,53.18) ; R551.1 v1(34.99,53.31) ; v1(226.93,108.43) 226.93,108.95 PC15.2 ; U43.1 v1(36.85,11.99) ; U43.4 v1(39.45,15.8) ; v1(30.38,98.61) D29.8 ; v1(19.66,99.11) D45.8 ; U43.2 v1(39.34,13.26) ; D55.P v1(4.69,93.9)
  BOTTOM w0.504: v1(197.02,64.16) 197.02,63.47 C301.1 ; v1(187.01,64.09) 187.06,64.04 C305.2 ; C298.2 207.13,64.04 v1(207.05,64.13) ; v1(209.58,64.08) 209.54,64.04 C290.2 ; C306.2 188.9,63.5 189.4,64 189.4,63.91 C307.2 ; v1(199.51,64.13) C299.1
  BOTTOM w0.508: 226.29,38.43 226.86,39 ; 226.29,38.43 226.29,38.56 ; 226.29,38.43 226.29,36.9 225.98,36.6 CN14.9 ; 226.86,39 227.63,39 228.89,40.25 v1(232.93,40.25) ; 226.86,39 226.29,39 ; C718.1 215.82,81.25 v1(215.7,81.13) ; v1(61.55,18.96) 61.53,18.98 C536.1 ; C885.1 203.26,31.77 C886.1 203.33,32.37 R732.2 ; v1(193.39,69.25) 193.62,69.02 C317.2 ; v1(190.78,61.77) 190.78,61.52 190.42,61.16 C302.1 ; v1(196.13,69.25) 195.97,69.08 C288.2 ; 226.29,38.56 226.29,39 ; 226.29,38.56 225.84,39 ; v1(194.54,64.07) 194.52,64.05 C297.2 ; C309.2 197.88,61.38 v1(198.3,61.8) ; v1(210.9,61.68) 210.66,61.44 C304.1 ; 226.29,39 225.84,39 ; 225.84,39 CN14.15 ; C68.1 v1(45.24,85.16) ; v1(46.58,85.13) 46.49,85.05 C69.1 ; R332.2 208.92,81.11 v1(208.93,81.13) ; v1(214.71,80.33) 214.61,80.43 C366.1 ; v1(205.8,61.74) 205.75,61.69 C319.2 ; C310.2 188.28,61.32 v1(188.28,61.8) ; v1(198.88,69.22) 198.79,69.13 C303.1 ; v1(201.62,69.22) 201.52,69.12 C312.2 ; PC14.2 v1(207.9,106.22) ; C358.1 174.74,75.95 v1(174.79,76) ; C296.2 204.47,63.5 v1(204.47,64.06) ; v1(63.75,81.19) 63.75,81.19 U36.4 ; C465.2 232.34,102.71 v2(232.34,102.99) ; C311.2 arc(212.08,63.68) v1(212.06,64.06)
  BOTTOM w0.61: v1(53.94,99.79) 54.37,99.36 U27.2
  vias: v1(12.15,107.61) v1(13.36,113.23) v1(13.51,106.46) v1(14.41,104.46) v1(14.52,99.67) v1(14.67,97.07) v1(15.16,92.93) v1(18.7,91.26) v1(21.71,90.56) v1(22.04,43.76) v1(22.09,42.7) v1(22.55,91.76) v1(24.26,104.86) v1(24.27,103.02) v1(26.3,48.63) v1(26.34,47.5) v1(26.34,46.49) v1(27.2,48.51) v1(27.2,47.49) v1(27.2,46.48) v1(28.7,65.37) v1(28.83,81.83) v1(28.82,81.07) v1(28.83,80.31) v1(28.8,79.04) v1(28.79,48.51) v1(28.79,47.49) v1(28.79,46.48) v1(29.68,81.09) v1(29.69,80.34) v1(29.7,79.76) v1(29.96,65.4) v1(30.55,69.66) v1(30.65,70.17) v1(30.83,71.33) v1(31.14,75.17) v1(31.07,69.65) v1(31.17,74.68) v1(31.34,72.63) v1(31.33,72.12) v1(31.33,71.59) v1(31.57,69.64) v1(33.69,28.3) v1(34.08,25.23) v1(34.1,23.15) v1(34.41,46.42) v1(34.38,31.28) v1(34.56,69.43) v1(37.68,64.73) v1(38.24,68.23) v1(38.64,70.27) v1(38.73,65.4) v1(38.76,8.09) v1(40.58,31.26) v1(40.66,28.48) v1(41.14,8.76) v1(41.3,29.2) v1(42.47,106.54) v1(43.5,8.25) v1(43.6,70.29) v1(45.85,86.38) v1(46.14,32.6) v1(46.44,86.37) v1(46.5,8.17) v1(46.68,30.24) v1(46.89,33.64) v1(47.22,31.46) v1(47.55,28.97) v1(48.02,32.6) v1(48.91,28.45) v1(49.67,15.29) v1(49.67,14.84) v1(50.03,8.85) v1(51.11,26.66) v1(51.11,25.39) v1(51.11,24.15) v1(51.27,14.57) v1(51.39,15.06) v1(51.66,17.02) v1(52.44,93.47) v1(52.45,92.74) v1(52.38,26.66) v1(52.38,25.39) v1(52.38,24.15) v1(53.48,99.76) v1(53.65,26.66) v1(53.65,25.39) v1(53.65,24.15) v1(54.29,92.72) v1(54.67,109.03) v1(55.14,109.06) v1(55.51,92.76) v1(56.3,34.73) v1(56.51,78.91) v1(56.82,11.87) v1(56.77,10.78) v1(56.89,15.6) v1(57.22,14.89) v1(57.42,80.63) v1(57.37,15.59) v1(57.82,18.74) v1(57.82,18.2) v1(58.2,29.95) v1(58.35,18.75) v1(58.35,18.21) v1(59.1,23.54) v1(59.35,79.35) v1(59.54,109.51) v1(60.42,72.99) v1(62.02,68.23) v1(62.38,65.44) v1(64.1,104.54) v1(64.1,104.06) v1(67.6,84.27) v1(68.11,79.09) v1(68.87,84.27) v1(69.24,75.93) v1(69.93,79.1) v1(70.14,84.27) v1(70.84,56.99) v1(70.84,56.48) v1(71.04,79.09) v1(71.05,70.88) v1(71.06,69.81) v1(71.41,84.27) v1(72.1,69.81) v1(72.68,84.27) v1(72.96,79.09) v1(73.13,70.88) v1(73.18,69.81) v1(73.55,57.16) v1(73.95,84.27) v1(73.89,56.79) v1(73.93,40.74) v1(73.93,38.2) v1(73.93,35.66) v1(73.93,33.12) v1(73.93,30.58) v1(73.93,28.04) v1(73.93,25.5) v1(73.93,22.96) v1(73.93,20.42) v1(74.06,79.05) v1(74.8,43.22) v1(75.22,84.27) v1(75.84,79.07) v1(76.06,57.13) v1(76.29,45.2) v1(76.49,84.27) v1(76.78,57.19) v1(77.03,79.1) v1(77.76,84.27) v1(78.34,46.73) v1(78.8,79.05) v1(79.04,76.35) v1(79.67,73.82) v1(80.23,81.64) v1(80.18,80.14) v1(80.43,83.29) v1(80.47,47.59) v1(80.89,76.72) v1(81.28,80.86) v1(81.5,79.34) v1(81.65,82.45) v1(82.61,47.83) v1(84.49,111.06) v1(85.15,47.76) v1(87.69,47.76) v1(90.23,47.76) v1(91.91,105.22) v1(92.36,105.22) v1(92.83,105.22) v1(93.32,105.22) v1(98.88,74.69) v1(100.39,47.76) v1(102.93,47.76) v1(102.99,77.77) v1(103.34,81.98) v1(103.63,76.51) v1(104.74,104.07) v1(105.24,77.07) v1(105.28,104.07) v1(105.47,47.76) v1(105.79,104.07) v1(106.14,55.54) v1(106.29,104.07) v1(106.74,104.07) v1(106.71,77.25) v1(106.75,76.2) v1(107.21,104.07) v1(107.7,104.07) v1(108.01,47.76) v1(110.36,75.83) v1(110.55,47.76) v1(110.79,73.02) v1(112.88,115.44) v1(113.09,47.76) v1(113.27,75.57) v1(113.62,54.3) v1(113.86,53.87) v1(114.35,62.84) v1(114.47,53.87) v1(114.72,54.3) v1(114.9,62.86) v1(115.16,47.76) v1(115.42,115.44) v1(115.41,62.84) v1(115.63,47.76) v1(116.14,76.88) v1(117.1,47.77) v1(117.69,47.75) v1(117.96,115.44) v1(118.17,47.76) v1(120.5,115.44) v1(120.56,94.82) v1(120.71,47.76) v1(121.42,47.76) v1(121.94,47.76) v1(121.99,95.04) v1(122.42,47.77) v1(123.04,115.44) v1(125.81,88.65) v1(125.79,47.76) v1(126.2,88.4) v1(126.73,115.46) v1(128.08,47.77) v1(129.01,115.44) v1(131.55,115.44) v1(134.09,115.44) v1(134.42,47.34) v1(135.66,46.85) v1(136.02,100.45) v1(136.97,45.96) v1(137.81,100.45) v1(138.12,44.94) v1(139.17,43.47) v1(139.44,90.31) v1(139.62,42.47) v1(140.3,39.5) v1(140.32,37.2) v1(142.66,17.76) v1(143.03,49.08) v1(143.35,48.58) v1(143.44,103.28) v1(144.24,110.69) v1(144.79,110.67) v1(145.55,110.67) v1(145.86,75.01) v1(145.85,74.49) v1(145.87,75.47) v1(146.02,110.68) v1(146.15,69.82) v1(146.16,69.37) v1(146.67,94.91) v1(146.67,94.4) v1(146.83,110.67) v1(146.96,74.61) v1(147.03,60.05) v1(147.1,72.55) v1(147.18,94.91) v1(147.18,94.4) v1(147.32,110.68) v1(147.65,72.53) v1(147.63,55.38) v1(147.69,94.91) v1(147.69,94.4) v1(147.84,17.75) v1(148.15,55.37) v1(148.19,94.91) v1(148.19,94.4) v1(148.5,110.68) v1(148.7,94.91) v1(148.7,94.4) v1(149.05,110.66) v1(148.97,82.41) v1(149.3,84.06) v1(149.75,71.24) v1(149.92,84.8) v1(149.95,16.25) v1(149.89,13.76) v1(149.91,10.62) v1(149.92,7.25) v1(150.11,66.61) v1(150.16,70.95) v1(150.41,82.44) v1(150.55,61.31) v1(150.59,83.93) v1(150.8,41.92) v1(153.74,91.78) v1(153.73,7.25) v1(155.64,34.61) v1(155.72,84.44) v1(155.66,39.14) v1(155.71,38.36) v1(155.81,84.94) v1(155.8,42.17) v1(156.26,84.67) v1(156.59,85.73) v1(156.75,39.78) v1(156.77,40.89) v1(157.54,7.25) v1(157.62,96.25) v1(157.63,95.74) v1(157.63,88.9) v1(157.75,89.68) v1(158.1,96.25) v1(158.11,95.73) v1(158.31,44.39) v1(158.52,93.31) v1(158.6,95.91) v1(158.93,43.84) v1(159.04,96.17) v1(159.08,95.64) v1(159.41,91.79) v1(159.75,49.55) v1(159.77,91.46) v1(159.87,91.93) v1(161.28,27.24) v1(161.35,7.25) v1(161.39,15.59) v1(163.36,29.8) v1(163.78,44.65) v1(164.23,26.49) v1(164.44,97.04) v1(164.48,96.1) v1(164.55,46.74) v1(164.52,28.04) v1(165.12,26.47) v1(165.25,97) v1(165.23,96.15) v1(165.24,53.89) v1(165.16,7.25) v1(165.51,53.45) v1(165.76,64.2) v1(166.22,27.79) v1(166.23,26.47) v1(166.31,46.76) v1(166.4,28.98) v1(167.09,60.74) v1(168.99,28.6) v1(168.97,7.25) v1(169.88,29.78) v1(170.71,27.23) v1(171.04,90.07) v1(171.21,88.32) v1(172.36,88.77) v1(172.78,7.25) v1(172.99,28.96) v1(173.65,87.95) v1(173.66,88.46) v1(173.8,27.2) v1(175.38,89.91) v1(175.81,91.35) v1(175.85,28.55) v1(175.77,27.15) v1(176.38,88.37) v1(176.59,7.25) v1(177.61,92.61) v1(178.22,75.92) v1(178.25,75) v1(178.26,74.53) v1(178.3,74.05) v1(178.29,73.56) v1(178.52,91.26) v1(179.22,27.82) v1(179.52,29.68) v1(180.4,7.25) v1(181.25,92.6) v1(181.35,94.6) v1(181.32,94.11) v1(181.28,91.98) v1(181.4,89.3) v1(181.48,91.16) v1(181.53,87.4) v1(182.67,89.3) v1(182.79,91.15) v1(182.8,87.4) v1(184.25,71.44) v1(184.31,87.48) v1(186.11,53.77) v1(186.25,95.99) v1(186.25,95.5) v1(186.16,55.58) v1(186.4,91.71) v1(186.41,91.2) v1(188.02,55.74) v1(188.03,53.9) v1(189.33,54.65) v1(189.35,52.81) v1(189.36,56.48) v1(189.55,16.98) v1(190.05,88.13) v1(190.92,91.04) v1(190.99,70.16) v1(191.05,27.78) v1(191.42,91.05) v1(192.28,79.25) v1(192.31,14.71) v1(192.42,36.2) v1(192.44,34.18) v1(192.79,79.24) v1(193.55,52.42) v1(193.59,57.02) v1(193.59,56.37) v1(194.85,53.76) v1(194.86,55.66) v1(196.15,54.18) v1(196.18,56.03) v1(196.16,52.22) v1(197.35,54.64) v1(197.41,56.52) v1(197.71,14.34) v1(198.07,115.33) v1(198.74,78.73) v1(199.18,52.63) v1(199.29,115.3) v1(199.47,55.65) v1(199.78,90.75) v1(200.13,78.74) v1(200.47,55.72) v1(200.58,115.34) v1(201.58,70.17) v1(201.7,115.32) v1(202.12,70.17) v1(202.09,55.69) v1(202.06,53.86) v1(202.63,70.19) v1(202.93,115.31) v1(203.16,70.19) v1(203.2,55.11) v1(203.26,7.25) v1(203.7,78.7) v1(203.79,92.02) v1(203.81,91.55) v1(203.78,89.7) v1(204.15,115.3) v1(204.44,55.13) v1(204.5,80.29) v1(204.51,53.23) v1(205.03,91.25) v1(205.02,89.43) v1(205.15,80.26) v1(205.33,115.29) v1(205.69,104.99) v1(205.88,56.86) v1(205.92,54.96) v1(206.18,79.67) v1(206.21,27.15) v1(206.58,115.3) v1(206.65,89.3) v1(206.64,87.43) v1(206.95,29.79) v1(207.07,7.25) v1(207.43,56.75) v1(207.4,54.9) v1(207.81,115.29) v1(208.41,56.76) v1(208.53,54.93) v1(208.49,29.16) v1(209.07,115.31) v1(209.77,27.78) v1(209.99,29.2) v1(210.74,92.06) v1(210.79,91.53) v1(210.94,99.54) v1(210.88,7.25) v1(211.45,99.54) v1(211.68,67.73) v1(211.94,99.55) v1(212.44,29.8) v1(212.73,26.45) v1(214.23,54.91) v1(214.23,53.01) v1(214.22,51.05) v1(214.69,7.25) v1(215.84,57.06) v1(215.83,55.23) v1(215.83,53.4) v1(216.45,30.11) v1(216.97,115.39) v1(217.58,28.11) v1(217.78,57.77) v1(217.78,56.52) v1(217.81,54.61) v1(218.5,7.25) v1(218.94,57.75) v1(219.22,66.01) v1(219.38,64.26) v1(219.48,29.8) v1(219.48,18.26) v1(219.82,115.45) v1(220.22,83.14) v1(220.8,56.49) v1(220.8,54.54) v1(221,66.27) v1(222.03,68.6) v1(222.56,70.08) v1(222.81,57.64) v1(223.1,70.07) v1(223.55,7.31) v1(223.63,115.45) v1(223.66,15.57) v1(223.93,68.54) v1(224.02,7.29) v1(224.09,16.01) v1(224.3,15.12) v1(225.15,43.33) v1(225.15,42.82) v1(225.23,7.33) v1(225.76,7.32) v1(226.23,7.33) v1(227.2,7.42) v1(227.68,7.4) v1(229.39,28.41) v1(229.63,28.81) v1(229.75,21.79) v1(229.78,22.28) v1(230.23,115.45) v1(230.32,22.26) v1(233.18,110.18) v1(233.28,47.9) v1(233.74,60.74) v1(233.74,60.22) v1(233.92,37.32) v1(234.04,115.45) v1(233.96,36.76) v1(234.11,113.4) v1(234.11,109.59) v1(234.06,93.71) v1(234.11,67.68) v1(234.15,65.18) v1(234.14,22.01) v1(234.14,21.52) v1(234.14,21.04) v1(234.16,16.41) v1(234.16,7.24) v2(0.98,115.28) v2(0.98,112.74) v2(0.98,110.2) v2(0.98,108.17) v2(6.06,115.28) v2(6.16,108.16) v2(8.6,115.28) v2(11.14,115.28) v2(13.68,115.28) v2(14.05,113.29) v2(15.33,40.21) v2(15.33,38.31) v2(15.33,35.77) v2(15.33,33.23) v2(15.33,30.69) v2(15.33,28.15) v2(15.33,25.61) v2(15.33,23.07) v2(15.33,20.53) v2(15.34,7.42) v2(15.41,17.64) v2(15.41,14.03) v2(15.41,10.04) v2(15.52,87.24) v2(15.52,84.7) v2(15.52,82.16) v2(15.52,79.62) v2(15.52,76.57) v2(15.52,74.03) v2(15.49,53.47) v2(15.49,50.93) v2(16.22,115.28) v2(17.8,7.37) v2(18.76,115.28) v2(20.34,7.37) v2(20.41,35.77) v2(20.41,33.23) v2(20.41,30.69) v2(20.41,28.15) v2(20.41,25.61) v2(20.41,23.07) v2(20.41,20.53) v2(21.3,115.28) v2(22.88,7.37) v2(23.84,115.28) v2(24.04,110.17) v2(24.02,109.27) v2(24.98,60.84) v2(25.42,7.37) v2(25.83,60.86) v2(25.84,60.06) v2(26.38,115.28) v2(27.96,7.37) v2(28.92,115.28) v2(29.74,7.37) v2(31.46,115.28) v2(32.85,7.4) v2(34,115.28) v2(34.72,108.7) v2(35.13,66.65) v2(35.39,7.4) v2(36.54,115.28) v2(37.17,7.4) v2(37.46,109.06) v2(39.08,115.28) v2(39.46,7.38) v2(41.62,115.28) v2(42,7.38) v2(43.43,108.01) v2(43.78,7.38) v2(44.16,115.28) v2(44.23,108.02) v2(46.27,7.47) v2(46.7,115.28) v2(48.81,7.47) v2(49.24,115.28) v2(50.03,109.73) v2(51.09,109.72) v2(51.33,47.7) v2(51.35,46.92) v2(51.35,7.47) v2(51.48,42.28) v2(51.78,115.28) v2(52.19,103.58) v2(52.42,42.23) v2(52.38,41.44) v2(52.39,40.66) v2(53.44,16.31) v2(53.89,7.47) v2(54.32,115.28) v2(56.43,7.47) v2(56.86,115.28) v2(58.08,109.61) v2(58.8,109.61) v2(58.97,7.47) v2(59.4,115.28) v2(61.51,7.47) v2(61.94,115.28) v2(64.05,7.47) v2(64.13,101.73) v2(64.15,100.92) v2(64.48,115.28) v2(66.59,7.47) v2(67.02,115.28) v2(69.56,115.28) v2(69.86,7.37) v2(70.12,19.46) v2(70.29,21.35) v2(70.32,20.45) v2(70.98,21.91) v2(72.1,115.28) v2(72.52,8.64) v2(73.81,12.48) v2(73.89,17.08) v2(74.64,115.28) v2(75.3,58.03) v2(75.3,57.22) v2(77.18,115.28) v2(82.39,115.28) v2(84.8,115.28) v2(87.34,115.28) v2(89.88,115.28) v2(91.89,105.82) v2(92.11,85.16) v2(92.11,84.4) v2(92.11,83.64) v2(92.18,68.91) v2(92.42,115.28) v2(92.62,105.81) v2(92.69,70.28) v2(92.68,69.49) v2(92.87,85.16) v2(92.87,84.4) v2(92.87,83.64) v2(93.33,105.83) v2(93.54,80.87) v2(93.55,80.06) v2(93.64,85.16) v2(93.64,84.4) v2(93.64,83.64) v2(93.88,75.4) v2(93.88,74.53) v2(94.31,80.85) v2(94.3,80.08) v2(94.66,76.24) v2(94.73,75.42) v2(94.73,74.55) v2(94.96,115.28) v2(97.33,78.93) v2(97.5,115.28) v2(98.1,78.98) v2(98.24,94.88) v2(98.25,94.09) v2(98.47,78.33) v2(98.84,78.97) v2(99,94.88) v2(99.01,94.09) v2(99.76,94.88) v2(99.77,94.09) v2(100.04,115.28) v2(100.51,94.88) v2(100.52,94.09) v2(102.58,115.28) v2(103.1,94.95) v2(103.11,94.16) v2(103.86,94.95) v2(103.87,94.16) v2(104.85,102.93) v2(105.12,115.28) v2(105.66,102.93) v2(106.5,102.93) v2(107.28,102.96) v2(107.66,115.28) v2(117.99,88.66) v2(117.99,87.77) v2(120.98,54.39) v2(120.96,53.61) v2(121.7,54.38) v2(121.68,53.63) v2(121.81,82.77) v2(121.82,82.04) v2(122.41,53.62) v2(122.46,54.35) v2(122.57,82.77) v2(122.58,82.04) v2(123.12,53.62) v2(123.17,54.35) v2(123.33,82.77) v2(123.34,82.04) v2(125.59,62.71) v2(125.89,63.36) v2(126.39,62.8) v2(127.49,112.87) v2(127.62,69.68) v2(127.59,68.91) v2(128.42,69.67) v2(128.4,68.91) v2(129.94,88.51) v2(130.29,58.7) v2(130.7,88.51) v2(131.12,58.7) v2(131.95,58.7) v2(136.05,83.31) v2(136,82.48) v2(135.99,81.72) v2(136.78,83.28) v2(136.79,82.48) v2(136.8,81.72) v2(138.14,115.28) v2(139.22,83.28) v2(139.24,82.52) v2(139.19,81.76) v2(140.45,25.62) v2(140.45,23.08) v2(140.45,20.54) v2(140.45,18) v2(140.48,31.62) v2(140.48,29.08) v2(140.68,115.28) v2(140.71,57.75) v2(140.68,56.94) v2(141.45,57.74) v2(141.44,56.96) v2(142.15,56.92) v2(142.18,57.74) v2(143.22,115.28) v2(145.76,115.28) v2(146.85,78.09) v2(148.3,115.28) v2(153.58,115.33) v2(153.72,96.3) v2(154.48,96.3) v2(158.66,115.33) v2(161.2,115.33) v2(162.62,51.71) v2(163.74,115.33) v2(165.3,105.67) v2(165.92,106.12) v2(166.28,115.33) v2(166.41,105.49) v2(166.77,106.12) v2(167.17,105.49) v2(167.93,105.49) v2(168.69,105.49) v2(169.42,105.49) v2(170.19,105.49) v2(170.85,115.3) v2(170.95,105.49) v2(171.43,100.95) v2(171.71,105.49) v2(172.16,101.01) v2(172.89,100.97) v2(173.39,115.3) v2(185.17,114.71) v2(185.22,113.95) v2(185.95,114.71) v2(186,113.94) v2(186.07,113.23) v2(186.71,114.72) v2(186.76,113.96) v2(186.81,113.24) v2(187.57,114.79) v2(187.59,114.05) v2(187.61,113.31) v2(192.39,114.89) v2(192.43,114.04) v2(192.45,113.24) v2(193.1,114.86) v2(193.15,114.02) v2(193.18,113.22) v2(193.82,114.84) v2(193.86,114) v2(193.94,113.2) v2(194.58,114.82) v2(194.63,113.97) v2(194.64,100.64) v2(194.67,113.22) v2(194.99,99.96) v2(195.35,100.62) v2(196.15,99.74) v2(196.94,99.65) v2(201.31,104.87) v2(201.29,103.64) v2(201.34,102.31) v2(202.33,104.86) v2(202.33,103.56) v2(202.3,102.35) v2(214.47,115.21) v2(214.52,114.4) v2(214.53,113.62) v2(214.53,112.83) v2(215.2,115.22) v2(215.25,114.41) v2(215.29,113.66) v2(215.29,112.84) v2(215.97,115.17) v2(216,114.43) v2(216.05,113.62) v2(216.05,112.78) v2(219.26,97.26) v2(222.76,103.93) v2(222.76,102.79) v2(222.76,101.64) v2(223.9,103.93) v2(223.9,102.79) v2(223.9,101.64) v2(225.04,103.93) v2(225.04,102.79) v2(225.04,101.64) v2(233.55,84.08) v2(233.53,78.03) v2(233.61,82.08) v2(233.61,80.56) v2(233.6,76.14) v2(233.67,91.75) v2(233.72,90.13) v2(233.74,88.62) v2(233.69,86.15) v2(233.98,74.12) v2(233.96,72.91) v2(233.97,71.63)

# Allegro board Lengda_AX1E_MAIN_r1.02_allegro.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_EARTH:
  vias: v1(67.61,89.46) v1(67.6,85.37) v1(67.82,94.9) v1(67.83,92.9) v1(68.87,85.37) v1(69.08,96.28) v1(69.26,94.32) v1(70.14,85.37) v1(71.08,90.19) v1(71.35,88.44) v1(71.41,85.37) v1(71.65,101.17) v1(71.72,97.3) v1(72.41,88.48) v1(72.68,85.37) v1(72.81,94.4) v1(73.95,85.37) v1(74.62,99.23) v1(74.64,94.69) v1(75.22,85.37) v1(76.26,89.94) v1(76.49,85.37) v1(76.91,97.5) v1(77.25,88.44) v1(77.76,85.37) v1(78.01,90.8) v1(78.19,95.46) v1(78.6,88.45) v1(79.31,86.17) v1(80.15,87.51) v2(67.73,102.14) v2(67.69,101.39) v2(67.68,100.65) v2(68.46,101.37) v2(68.45,100.63) v2(68.5,102.12) v2(80.41,96.67) v2(80.41,95.91) v2(80.41,95.15) v2(80.41,94.38) v2(81.18,96.67) v2(81.18,95.91) v2(81.18,95.15) v2(81.18,94.38)
P1.9V_VCT: length 17.8
  TOP w0.305: 73.45,76.39 73.34,76.51 70.67,76.51 C6039.2 70.48,76.39 ; 73.45,76.39 C6040.2 73.65,76.52 75.94,76.52 76.08,76.38 C6041.2 ; 73.45,76.39 U31.7 ; C6041.2 76.49,75.63 R814.2 75.94,74.08 R813.1 ; C6041.2 76.42,76.45 U31.10 ; U31.4 70.48,76.39 ; 70.48,76.39 70.36,76.52 67.95,76.52 C6038.2 67.51,76.64 U31.1
V1.05A_BYPASS: length 18.7
  TOP w0.076: U1.DJ15 173.82,78.78 174.13,78.46 v1(174.13,77.62)
  TOP w0.127: R111.2 159.39,77.38 v1(160.09,76.68)
  ART06 w0.102: v1(160.09,76.68) 160.09,76.62 161.46,75.26 168.07,75.26 169.9,77.09 173.6,77.09 v1(174.13,77.62)
V1.05A_PWRGD: length 143.6
  TOP w0.203: v1(53.75,63.3) 53.11,63.94 53.11,69.64 53.87,70.4 53.87,73.28 51.92,75.23 51.71,75.23 48.92,78.03 48.92,79.42 48.97,79.48 v1(48.97,79.5) ; v1(148.38,101.89) 148.76,101.51 148.76,100.25 R205.2 149.24,99.09 147.91,97.76 U24.7
  ART06 w0.203: v1(148.38,101.89) 148.38,102.65 146.25,104.78 143.88,104.78 143.28,105.38 138.34,105.38 137.89,104.93 133.48,104.93 131.58,106.83 125.87,106.83 112.21,93.17 87.63,93.17 85.1,90.64 85.1,85.24 83.85,83.99 80.14,83.99 78.31,82.17 63.79,82.17 60.09,78.47 55.34,78.47 53.86,79.95 49.41,79.95 48.96,79.51 v1(48.97,79.5)
  BOTTOM w0.203: v1(53.75,63.3) 53.76,63.29 U9.2
V1.8A_VR_PWRGD: length 46.1
  TOP w0.203: R858.1 152.73,100.42 152.95,100.2 152.95,98.07 v1(154.06,96.95)
  TOP w0.305: v1(157.66,83.4) 157.64,83.4 156.72,82.48 155.02,82.48 153.98,81.44 151.93,81.44 151.68,81.19 148.95,81.19 R234.2 148.78,81.16 148.78,78.9 148.47,78.59 U51.4
  ART06 w0.102: v1(157.66,83.4) 156.76,84.31 156.76,85.01 154.64,87.13 154.64,88.79 155.44,89.6 155.47,89.6 156.01,90.14 156.01,90.7 155.86,90.85 155.86,93.65 155.59,93.93 155.59,95.99 154.62,96.95 v1(154.06,96.95)
  BOTTOM w0.203: R327.1 163.7,92.21 163.21,91.72 162.38,91.72 161.01,91.15 159.12,89.26 159.12,87.52 157.66,86.06 v1(157.66,83.4)
V3.3_5A_EN: length 37
  TOP w0.203: v1(94.81,90.58) 94.81,90.98 94.67,91.13 R227.1 94.35,91.91 R228.1
  TOP w0.305: R898.2 94.79,90.56 v1(94.81,90.58)
  ART03 w0.305: v1(121.12,86.73) 121.12,84.83 v1(121.57,84.38)
  ART06 w0.305: v1(94.81,90.58) 95,90.39 114.37,90.39 118.03,86.73 v1(121.12,86.73)
  BOTTOM w0.305: v1(121.57,84.38) 120.09,82.9 R900.2
V3.3_5A_EN_EC: length 62.6
  TOP w0.203: R227.2 93.48,91.13 94.3,90.31 94.3,89.72 93.97,89.38 93.97,87.92 v1(93.57,87.52)
  ART06 w0.152: v1(93.57,87.52) 93.45,87.41 91.58,87.41 86.04,81.87 86.04,81.26 86.04,81.26 86.04,77.02 84.16,75.14 78.8,75.14 78.47,74.81 67.04,74.81 63.76,78.09 62.74,78.09 61.79,77.15 54.59,77.15 54.3,77.43 47.67,77.43 46.96,76.72 46.96,76.55 v1(47.04,76.47)
  BOTTOM w0.203: U9.78 46.96,76.55 v1(47.04,76.47)
V3.3_5A_EN_IC: length 8.1
  TOP w0.203: R228.2 90.46,91.92 89.75,91.21 89.75,90.18 90.47,89.45 C26.2 90.47,88.9 91.1,88.27 U7.11
V3.3A_PWRGD: length 145.4
  TOP w0.102: R215.1 147.08,81.78 146.65,82.21 146.65,82.71 145.75,83.61 143.33,83.61 142.14,82.41 142.14,75.52 140.92,74.31 133.46,74.31 133.08,73.92 131.39,73.92 130.71,74.6 121.71,74.6 121.28,75.03 121.28,75.7 121.57,75.99 121.57,77.3 121.14,77.73 R37.2
  TOP w0.203: R37.2 121.14,77.92 v1(122.24,79.02) U20.7
  ART06 w0.152: v1(122.24,79.02) 122.24,80.45 119.18,83.51 95.59,83.51 94.91,82.83 89.95,82.83 87.58,80.47 87.58,75.85 85.22,73.48 82.81,73.48 81.07,71.73 66.66,71.73 62.59,75.81 59.04,75.81 58.38,76.47 54.43,76.47 53.98,76.92 51.73,76.92 50.44,75.63 48.37,75.63 48.36,75.62 v1(46.69,75.62)
  BOTTOM w0.152: v1(46.69,75.62) 46.64,75.58 46.64,73.91 45.29,72.55 45.29,69.57 43.11,67.39 43.11,64.71 42.05,63.65 U9.33
V5A_PWRGD: length 82.4
  TOP w0.203: U7.7 92.9,88.11 92.96,88.16 v1(93.27,88.16) 93.38,88.27 R34.2
  ART06 w0.152: v1(50.29,74.78) 49.92,74.41 49.03,74.41 48.47,74.97 46.1,74.97 45.57,75.5 45.57,77.4 45.86,77.69 54.41,77.69 54.69,77.4 61.64,77.4 62.69,78.45 63.85,78.45 67.24,75.07 78.3,75.07 78.64,75.41 83.97,75.41 85.72,77.16 85.72,82 91.45,87.73 92.52,87.73 92.96,88.16 v1(93.27,88.16)
  BOTTOM w0.102: v1(50.29,74.78) 51.09,74.78 51.69,74.18 51.69,69.4 51.16,68.87 51.16,68.44 49.65,66.93 49.65,66.05 48.16,64.56 U9.16
VCC2_USB2.0: length 3.2
  TOP w0.305: 49.06,108.52 R929.2 ; 49.06,108.52 48.62,108.96 ; 49.06,108.52 48.97,108.52 ; 48.97,108.52 48.64,108.2 ; 48.97,108.52 48.5,108.52
VCC_8625: length 26.7
  ART03 w0.406: v1(48.09,17.66) 47.09,17.66 v1(45.86,16.44)
  ART06 w0.508: v1(48.09,17.66) 48.09,18 49.48,19.38 51.32,19.38 54.29,22.36 v1(56.37,22.36)
  BOTTOM w0.203: U42.14 55.94,22.78 v1(56.37,22.36) ; 56.4,22.82 56.04,23.18 U42.13
  BOTTOM w0.305: R600.2 45.89,16.41 v1(45.86,16.44) ; U43.8 44.12,11.99 44.51,11.61 R606.1 45.75,11.74 R605.1 46.66,13.79 R595.2 46.66,14.53 R596.2 47.29,15.42 U44.8 48.39,16.47 C546.2 48.76,16.84 C547.1
  BOTTOM w0.508: v1(48.09,17.66) C547.1
VCC_SENSE: length 1.3
  BOTTOM w0.203: PR70.2 214.77,103.02 214.78,103.02 215.22,102.58 215.22,102.78 NS2.2
VCCIN_AUX: length 79.5
  TOP w0.125: 197.26,82.39 U1.AY9 ; U1.AY9 197.75,82.39 ; U1.AY9 197.26,81.89 ; U1.AY9 197.75,81.89 ; U1.CY11 178.12,81.38 ; U1.CY11 178.45,81.38 ; U1.CY11 178.12,81.05 ; U1.CY11 178.45,81.05 ; 180.74,81.84 U1.CR10 ; U1.CR10 180.74,81.51 ; U1.CR10 180.41,81.84 ; U1.CR10 180.41,81.51 ; U1.CM11 181.78,81.05 ; U1.CM11 181.78,81.38 ; U1.CM11 182.11,81.05 ; U1.CM11 182.11,81.38 ; U1.CP11 181.2,81.05 ; U1.CP11 181.2,81.38 ; U1.CP11 180.87,81.38 ; U1.CP11 180.87,81.05 ; 197.3,81.43 U1.BA10 196.8,81.92 ; 199.09,82.39 U1.AT9 ; U1.AT9 199.09,81.89 ; U1.AT9 199.58,81.9 ; U1.AT9 199.58,82.39 ; 176.62,81.38 U1.DC11 ; U1.DC11 176.29,81.38 ; U1.DC11 176.62,81.05 ; U1.DC11 176.29,81.05 ; U1.CL10 182.57,81.84 ; U1.CL10 182.24,81.84 ; U1.CL10 182.57,81.51 ; U1.CL10 182.24,81.51 ; 198.63,81.92 U1.AU10 ; U1.AU10 199.13,81.92 ; U1.AU10 199.13,81.43 ; 197.96,81.67 U1.AW10 ; U1.AW10 198.21,81.92 ; U1.AW10 197.71,81.92 ; U1.AW10 197.71,81.43 ; U1.DE12 175.59,80.73 ; U1.DE12 175.94,80.38 ; U1.DE12 175.59,80.38 ; U1.DE12 175.94,80.73 ; 196.84,82.39 U1.BB9 196.84,81.89 ; 198.67,82.39 U1.AV9 ; U1.AV9 198.67,81.89 ; U1.AV9 198.17,81.89 ; U1.AV9 198.17,82.39 ; 179.83,81.51 U1.CU10 ; U1.CU10 179.5,81.84 ; U1.CU10 179.5,81.51 ; U1.CU10 179.83,81.84 ; 210.35,80.12 U1.P13 210.35,79.62 ; U1.CV11 179.04,81.38 ; U1.CV11 179.37,81.05 ; U1.CV11 179.37,81.38 ; U1.CV11 179.04,81.05 ; 175.29,80.73 U1.DF12 175.29,80.38 ; 197.75,81.46 U1.AY11 ; U1.AY11 197.26,80.96 ; U1.AY11 197.75,80.96 ; U1.AY11 197.26,81.46 ; 178.91,81.51 U1.CW10 ; U1.CW10 178.58,81.51 ; U1.CW10 178.58,81.84 ; U1.CW10 178.91,81.84 ; 182.7,81.38 U1.CK11 182.7,81.05 ; 180.28,81.38 U1.CT11 ; U1.CT11 179.95,81.38 ; U1.CT11 179.95,81.05 ; U1.CT11 180.28,81.05 ; U1.T13 209.65,79.66 ; U1.T13 209.15,80.16 208.94,80.37 U1.U12 208.95,80.37 209.16,80.58 ; U1.T13 209.15,79.66 ; U1.CN10 181.33,81.51 ; U1.CN10 181.66,81.51 ; U1.CN10 181.33,81.84 ; U1.CN10 181.66,81.84 ; U1.AT11 199.09,80.96 ; U1.AT11 199.58,80.96 ; U1.AT11 199.09,81.46
  TOP w0.152: U1.DC1 176.76,86.63 v1(176.62,86.77) ; U1.CV1 v1(179.23,86.74)
  TOP w0.203: 198.87,82.41 v1(198.87,82.41) U1.AV9 ; U1.AY9 v1(197.95,82.41) 197.95,82.41 ; LPM5.2 161.46,99.46 160.96,98.95 v1(160.96,98.75) ; 199.78,82.41 v1(199.78,82.41) ; 197.04,82.41 v1(197.04,82.41)
  TOP w0.25: v1(184.35,86.26) 184.35,85.96 U1.CH1 ; v1(181.45,86.49) 181.45,86.04 U1.CN1
  TOP w0.305: PR119.1 164.82,104.02 v1(164.77,104.07)
  ART06 w0.406: v2(179.52,97.14) 177.62,99.04 164.92,99.04 161.7,102.26 v1(161.7,103.05)
  BOTTOM w0.075: v1(199.01,80.78) 198.77,81.02 198.77,81.47
  BOTTOM w0.203: v1(164.77,104.07) 164.82,104.11 164.82,104.35 163.76,105.4 157.85,105.4 154.28,101.83 154.28,99.21 155.03,98.46 157.14,98.46 PR60.1 158.35,98.89 PC52.2 158.38,98.94 158.92,99.48 160.22,99.48 v1(160.96,98.75) 160.83,98.75 160.06,97.97 PR117.2
  BOTTOM w0.305: v1(161.7,103.05) 161.6,103.05 161.11,102.57 PR64.1
  vias: v1(175.94,87.48) v1(177.04,80.8) v1(177.32,80.26) v1(178.21,80.26) v1(179.22,87.33) v1(179.2,80.29) v1(181,80.29) v1(182.04,80.25) v1(182.69,80.51) v1(197.07,81) v1(197.51,80.7) v1(197.92,81.01) v1(199.57,80.73) v1(200.89,86.69) v1(201.15,87.15) v1(201.38,86.7) v1(208.97,79.23) v1(209.57,79.28) v1(210.2,79.12) v2(169.21,93.46) v2(169.37,92.21) v2(169.59,94.62) v2(169.92,93.42) v2(170.19,92.17) v2(170.37,94.65) v2(170.63,93.48) v2(170.75,91.11) v2(170.93,91.81) v2(171.11,94.65) v2(171.25,93.1) v2(171.46,91.3) v2(171.78,94.33) v2(171.82,92.55) v2(171.91,90.7) v2(172.09,95.74) v2(172.28,93.72) v2(172.4,91.99) v2(172.63,95.2) v2(172.94,93.15) v2(173.17,94.67) v2(173.54,92.57) v2(173.69,94.15) v2(173.74,91.83) v2(173.75,91.07) v2(174.05,95.46) v2(174.18,93.63) v2(174.56,94.92) v2(174.74,93.12) v2(175.01,96.94) v2(175.1,94.41) v2(175.2,92.56) v2(175.26,91.79) v2(175.63,93.88) v2(175.71,96.14) v2(176.14,93.38) v2(176.38,95.62) v2(176.99,95.06) v2(178.84,96.88) v2(179.51,96.42) v2(220.82,71.82)
VCCIN_AUX_EN_R: length 2.1
  BOTTOM w0.203: R327.2 163.7,93.43 164.45,94.18 U6.19
VCCIN_AUX_FS: length 1.7
  BOTTOM w0.203: U6.9 165.25,98.46 165.26,98.46 165.26,98.48 165.63,98.86
  BOTTOM w0.305: 165.63,98.86 166.04,99.27 R309.2
VCCIN_AUX_PG: length 147.6
  ART06 w0.102: v1(154.94,100.11) 154.94,101.18 148.31,107.82 137.27,107.82 135.98,106.53 134.1,106.53 132.25,108.38 122.7,108.38 120.7,106.38 101.35,106.38 99.59,108.15 76.67,108.15 74.73,110.09 66.96,110.09 60.58,103.71 57.53,103.71 56.89,103.06 56.89,95.79 54.84,93.73 54.84,88.91 v1(54.02,88.1)
  BOTTOM w0.102: v1(54.02,88.1) 54.57,88.1 55.08,87.58 55.08,86.12 53.54,84.58 53.54,80.7 54.42,79.83 54.42,78.65 54.16,78.4 U9.96
  BOTTOM w0.203: U6.4 162.87,97.01 162.69,97.19 162.69,97.86 162.02,98.52 R139.2 162,99.24 161.38,99.86 155.19,99.86 v1(154.94,100.11)
VCCIN_AUX_VCCSENSE: length 45.9
  TOP w0.203: U1.BF9 v1(195.18,82.4)
  ART06 w0.203: v1(195.18,82.4) 195.17,82.4 194.72,82.85 194.72,83.25 191.81,86.15 191.81,87 189.56,89.25 185.84,89.25 184.1,91 184.1,93.7 178.07,99.73 165.18,99.73 163.65,101.25 163.65,101.99 v1(162.59,103.05)
  BOTTOM w0.305: PR61.1 162.3,102.42 162.59,102.72 ; 162.59,102.72 162.59,102.54 C6134.1 ; 162.59,102.72 v1(162.59,103.05)
VCCIN_AUX_VSSSENSE: length 43.9
  TOP w0.203: v1(196.1,82.4) 195.84,82.14 U1.BD9
  ART06 w0.203: v1(196.1,82.4) 195.94,82.4 195.68,82.66 195.68,83.21 195.28,83.61 194.83,83.61 192.14,86.3 192.14,87.19 189.74,89.59 186.01,89.59 184.46,91.15 184.46,93.85 178.22,100.08 166.19,100.08 164.79,101.49 v1(164.79,101.56)
  BOTTOM w0.305: PR66.1 164.19,100.24 164.79,100.83 v1(164.79,101.56)
VCCIN_SENSE: length 48.1
  TOP w0.203: v1(214.81,77.55) 214.56,77.79 U1.F17
  ART03 w0.203: v1(215.62,104.77) 215.62,104.42 216.02,104.02 216.23,104.02 216.51,104.3 216.51,104.3 216.53,104.33 216.53,105.05 216.03,105.56 215.19,105.56 214.61,104.97 214.61,103.49 214.59,103.47 213.51,102.4 213.51,98.05 216.12,95.44 222.76,95.44 224.27,93.94 224.27,90.78 224.27,90.49 221.1,87.32 221.1,86.25 220.8,85.95 220.79,85.95 219.23,84.39 219.23,81.49 217.04,79.3 216.56,79.3 v1(214.81,77.55)
  BOTTOM w0.203: v1(215.62,104.77) 214.77,104.77 214.43,104.44 214.43,104.12 PR51.2
  BOTTOM w0.305: PR55.2 215.11,77.85 v1(214.81,77.55)
VCCST_OVERRIDE_R: length 4.8
  TOP w0.076: 185.28,86.55 185.28,85.51 185.12,85.35 185.12,84.95 185.24,84.83 185.24,84.66 U1.CE4
  TOP w0.102: R288.1 185.28,88.55 185.28,86.55
VCCST_PWRGD: length 190.4
  TOP w0.102: v1(48.15,85.93) 47.98,85.76 47.98,80.34 48.43,79.9 48.43,78.06 52.19,74.29 Q12.3
  TOP w0.305: R102.1 184.81,91.4 v1(184.88,91.48)
  ART03 w0.102: v1(48.15,85.93) 48.15,89.49 50.79,92.13 50.79,106.52 52.68,108.41 55.34,108.41 55.89,108.95 59.88,108.95 v1(62.37,111.44)
  ART06 w0.203: v1(62.37,111.44) 62.37,111.95 64.89,114.47 76.47,114.47 78.65,112.29 81.9,112.29 83.06,113.46 84.7,113.46 85.4,114.16 90.01,114.16 90.72,113.46 91.35,113.46 91.63,113.73 102.81,113.73 103.08,113.46 111.03,113.46 111.98,114.4 132.32,114.4 134.56,112.16 137.57,112.16 138.12,112.71 160.02,112.71 162.23,110.5 162.23,107.67 164.9,105 165.95,105 166.39,104.56 170.7,104.56 174.03,101.23 177.85,101.23 184.88,94.2 v1(184.88,91.48)
VCCST_PWRGD_MCP: length 5.3
  TOP w0.075: R98.2 184.02,89.62 R102.2
  TOP w0.076: R102.2 184.7,89.51 184.7,87.26 185.11,86.85 185.11,85.72 U1.CF2
VCCST_PWRGD_TCSS: length 4.3
  TOP w0.076: 185.75,87.45 185.45,87.15 185.45,85.18 U1.CE3
  TOP w0.102: 185.75,87.45 185.75,88.23 R280.1
VDD12: length 16.4
  TOP w0.508: v1(62.03,25.96) 60.67,24.61 60.67,22.84 55.8,17.97 v1(55.8,17.01)
  BOTTOM w0.203: U42.19 53.33,21.1
  BOTTOM w0.305: FB11.2 v1(62.03,25.96) ; C549.2 C550.2 53.41,20.14 53.16,20.39 53.16,20.93 53.33,21.1
  BOTTOM w0.508: L10.1 v1(55.8,17.01)
VDDIO_8625: length 51.6
  TOP w0.406: v1(52.53,29.55) 52.56,29.58 C532.2
  TOP w0.508: FB3.2 53.96,30.62 FB9.2 53.66,30.32 52.63,30.32 C532.2
  ART03 w0.305: v1(61.63,23.25) 61.63,25.41 60.95,26.09 60.95,29.63 62.32,31 62.32,32.19 v1(62.17,32.34) ; v1(48.21,26.38) 48.21,19.52 48.95,18.77 48.95,16.98 49.73,16.19 v1(49.73,15.89)
  ART06 w0.305: v1(52.53,29.55) 53.59,30.61 60.45,30.61 v1(62.17,32.34)
  ART06 w0.406: v1(52.53,29.55) 49.36,26.38 v1(48.21,26.38) 46.32,24.49 v1(46.32,24.38)
  BOTTOM w0.203: v1(48.21,26.38) U42.38 ; U42.50 v1(52.53,29.55)
  BOTTOM w0.305: R588.2 61.71,23.18 v1(61.63,23.25) 60.91,22.54 60.91,22.38 R589.2 ; v1(49.73,15.89) 49.91,16.07 R603.2 49.91,16.77 R597.2 ; v1(52.53,29.55) 52.54,29.56 C531.2 ; C540.2 48.2,26.39 v1(48.21,26.38) ; R594.2 v1(46.32,24.38) ; R583.1 v1(62.17,32.34)
VDDRX: length 6.2
  BOTTOM w0.203: U42.6 56.69,25.98
  BOTTOM w0.305: FB11.1 61.08,27.39 C543.2 C542.2 59.1,26.59 58.22,26.59 C541.2 57.09,26.39 56.69,25.98
VIN_LCD: length 32.3
  TOP w0.406: v1(39.18,43.07) 39.07,42.96 35.96,42.96 v1(35.33,43.58) 31.76,47.15 v1(31.68,47.15)
  ART06 w0.406: v1(39.18,43.07) 42.75,39.49 54.04,39.49 55.26,40.71 v1(55.26,43.07)
  BOTTOM w0.305: R540.2 35.4,43.06 R544.2 35.41,43.51 v1(35.33,43.58) ; v1(31.68,47.15) U37.13
VSSIN_SENSE: length 50.7
  TOP w0.203: v1(214.19,77.55) 213.91,77.82 U1.G17
  ART03 w0.203: v1(216.4,103.05) 216.4,103.68 216.86,104.15 216.86,104.16 216.89,104.18 216.89,105.2 216.17,105.91 215.92,105.91 215.92,105.91 215.05,105.91 214.25,105.12 214.25,103.64 213.15,102.54 213.15,97.87 215.94,95.08 222.62,95.08 223.91,93.79 223.91,90.64 220.74,87.47 220.74,86.39 218.88,84.53 218.88,81.63 216.98,79.74 216.38,79.74 v1(214.19,77.55)
  BOTTOM w0.203: v1(216.4,103.05) 216.66,102.8 217.51,102.8 217.92,102.39 PR106.2
  BOTTOM w0.305: PR83.1 212.99,78.02 213.81,78.02 214.19,77.65 v1(214.19,77.55)
8625_BLEN: length 45
  ART03 w0.102: v1(51.44,21.12) 51.99,21.67 51.99,32.87 49.22,35.63 49.22,39.7 40.94,47.98 v1(40.94,52.12)
  BOTTOM w0.102: U42.23 51.73,21.43 51.44,21.13 v1(51.44,21.12) ; R554.2 33.73,54.01 39.06,54.01 v1(40.94,52.12)
8625_PD#: length 5.7
  BOTTOM w0.152: R589.1 59.5,21.92 58.64,21.92 C535.2 57.58,22.98 57.58,23.37 56.54,24.41 55.76,24.41 U42.10
8625_PWMO: length 39.6
  ART03 w0.102: v1(56.45,23.41) 55.82,23.41 54.7,24.52 54.7,30.94 49.67,35.98 v1(49.67,36.4)
  BOTTOM w0.102: R527.2 30.99,40.3 31.64,39.65 46.41,39.65 v1(49.67,36.4) ; v1(56.45,23.41) 56.41,23.41 56.24,23.58 U42.12
8625_RST#: length 11.5
  BOTTOM w0.152: U42.9 56.65,24.78 57.24,24.19 62.63,24.19 R588.1 63.47,24.13 C534.2 64.49,26.25 U57.4 64.83,26.92 R1397.1
+V_ADP_IN: length 5.3
  TOP w0.305: R174.2 90.42,107.89 C228.1 88.88,108.34 R170.2 ; R174.2 90.49,107.96 R1392.2 ; R174.2 90.48,107.93 90.48,106.71 R261.2
  vias: v2(97.01,101.86) v2(97.41,102.5) v2(97.78,101.86) v2(100.46,102.61) v2(100.45,101.89) v2(103.9,101.68) v2(103.9,100.91)
+VSYS_DCIN: length 54.1
  TOP w0.508: 116.97,59.32 115.98,59.32 115.25,58.58 115.25,58.27 114.78,57.8 114.78,56.79 113.99,56.01 111.22,56.01 110.76,55.55 v1(109.83,55.55)
  BOTTOM w0.305: R109.2 110.32,55.06 v1(109.83,55.55)
  BOTTOM w0.508: 208.76,112.9 208.76,113.91 ; 208.76,113.91 207.02,113.91 ; 208.76,113.91 209.66,114.81 212.44,114.81 213.31,113.94 213.31,112.31 214.1,111.51 216.12,111.51 217.07,112.46 217.07,113.34 218.01,114.28 223.31,114.28 223.99,114.96 226.7,114.96 227.1,114.57 229.59,114.57 230.32,113.83 230.32,110.18 PR41.2 ; R329.2 160.31,93.44 159.28,93.44 158.8,93.93 156.86,93.93 156.63,94.16 153.72,94.16 151.72,96.15
  vias: v2(68.47,49.38) v2(69.23,49.38) v2(70.07,49.32) v2(104.5,110.19) v2(104.5,109.37) v2(105.31,110.19) v2(105.31,109.37) v2(106.25,110.19) v2(106.25,109.37) v2(107.08,110.19) v2(107.08,109.37) v2(107.91,110.19) v2(107.91,109.37) v2(108.67,110.19) v2(108.67,109.37) v2(142.37,36.67) v2(142.4,35.86) v2(142.4,35.11) v2(144.71,106.85) v2(145.43,106.83) v2(146.16,106.85) v2(146.88,106.83) v2(147.6,106.89) v2(148.31,106.82) v2(150.08,97.46) v2(150.72,97.83) v2(150.74,97.11) v2(151.39,97.46) v2(169.16,109.83) v2(169.88,109.85) v2(170.63,109.83) v2(171.37,109.85) v2(172.14,109.84) v2(199.49,112.14) v2(200.33,112.16) v2(201.18,112.15) v2(203.55,112.1) v2(204.31,112.07) v2(206.83,112.07) v2(207.58,112.08) v2(208.33,112.07) v2(209.07,112.06) v2(229.48,36.88) v2(230.11,36.52) v2(230.25,37.21)
A_MUTE_MIC: length 40.2
  TOP w0.305: v1(30.03,91.23) 30.03,91.51 30.56,92.04 33.32,92.04 33.71,91.65 R508.1
  BOTTOM w0.305: J7.6 4.75,96.25 D52.N 6.23,94.78 10.02,94.78 11.12,93.68 11.12,92.7 12.45,91.36 13.3,91.36 17.65,87.01 21.19,87.01 22.07,86.13 28.59,86.13 29.9,87.45 29.9,91.1 v1(30.03,91.23)
AC_PRESENT: length 252.7
  TOP w0.075: 163.98,57.42 163.98,57.72 164.03,57.77 164.35,58.08 165.19,58.08 165.59,57.69 R31.2
  TOP w0.076: 170.87,56.64 171.28,57.04 171.28,57.65 174.27,60.64 174.58,60.64 175.38,61.44 175.38,62.48 175.34,62.59 175.34,62.84 175.41,62.97 175.46,63.1 175.46,63.7 U1.DE46
  TOP w0.102: v1(162.95,55.34) 163.07,55.46 163.07,55.63 163.22,55.79 163.22,56.67 R324.1 163.37,56.68 163.98,57.29 163.98,57.42 ; R31.2 166.16,57.69 166.7,57.15 168.31,57.15 169.33,56.12 170.36,56.12 170.87,56.64
  ART03 w0.102: v1(153.46,38.14) 154.3,38.98 154.3,45.8 155.17,46.67 156.54,46.67 156.84,46.97 156.84,49.69 157.54,50.38 157.54,51.5 158.42,52.39 160.04,52.39 161.69,54.04 162.37,54.04 163.1,54.77 163.1,55.19 v1(162.95,55.34)
  ART06 w0.102: v1(44.82,67.76) 46.68,67.76 50.15,64.28 50.15,59.57 49.55,58.97 49.55,56.11 50.15,55.51 73.12,55.51 74.3,54.33 78.7,54.33 80,53.03 81.49,53.03 82.85,54.38 101.05,54.38 101.93,53.5 104.58,53.5 105.1,54.02 110.57,54.02 111.76,55.21 115.32,55.21 116.52,56.4 125.6,56.4 127.44,54.57 135.46,54.57 139.36,50.67 139.36,50.2 145.2,44.35 151.66,44.35 153.57,42.44 153.57,38.25 v1(153.46,38.14)
  BOTTOM w0.102: U9.31 42.16,62.9 43.87,64.61 43.87,66.81 v1(44.82,67.76) ; R1396.2 217.02,37.42 208.82,37.42 207.08,39.17 188.7,39.17 187.09,37.56 181.71,37.56 179.48,35.32 156.77,35.32 156.55,35.54 154.76,35.54 153.61,36.69 153.61,37.99 v1(153.46,38.14)
ADP_IN#: length 272.1
  ART06 w0.102: v1(48.64,56.2) 48.54,56.09 48.54,54.15 48.81,53.87 49.29,53.87 49.84,54.42 72.8,54.42 73.93,53.29 v1(76.52,53.29) 78.28,53.29 79.27,52.3 83.13,52.3 84.56,53.73 100.47,53.73 101.42,52.77 104.99,52.77 105.6,53.38 111.7,53.38 111.92,53.16 114.64,53.16 116.02,54.54 117.02,54.54 118.2,55.72 125.24,55.72 127.15,53.81 135.24,53.81 138.58,50.47 138.58,49.91 145.52,42.98 148.42,42.98 151.11,40.29 151.57,40.29 151.9,39.95 v1(152.17,39.95)
  BOTTOM w0.102: D73.P 92.86,109.32 95.34,106.84 97.74,106.84 98.94,105.64 98.94,97.26 101.06,95.15 101.06,93.83 98.94,91.71 98.94,86.4 95.32,82.78 95.32,73.31 93.9,71.9 92.13,71.9 90.69,70.46 90.69,66.45 90,65.75 90,60.58 88.34,58.92 87.61,58.92 84.43,55.74 81.71,55.74 79.36,53.39 76.62,53.39 v1(76.52,53.29) ; R1394.2 42.44,56.12 42.88,55.68 45.17,55.68 45.79,56.31 48.54,56.31 v1(48.64,56.2) ; R1395.2 217.83,39.18 216.54,37.89 208.9,37.89 207.23,39.56 188.46,39.56 186.88,37.98 181.68,37.98 179.27,35.58 156.85,35.58 156.68,35.75 154.92,35.75 153.87,36.8 153.87,38.41 153.43,38.85 152.57,38.85 152.29,39.14 152.29,39.83 v1(152.17,39.95)
ADP_IN#_EC: length 8.5
  BOTTOM w0.102: R1393.2 40.59,57.07 ; 40.59,57.07 R1394.1 ; 40.59,57.07 40.73,57.21 40.73,58.67 R90.1 40.18,60.13 41.09,61.04 42.81,61.04 43.36,61.59 U9.28
ALL_SYS_PWRGD_VRON: length 232
  ART03 w0.102: v1(229.94,107.86) 229.94,110.12 228.78,111.29 224.28,111.29 224.01,111.02 221.17,111.02 217.98,107.83 197.26,107.83 194.59,110.5 184.22,110.5 183.59,111.13 182.21,111.13 181.6,110.52 177.75,110.52 175.87,112.4 139.53,112.4 137.51,110.38 134.17,110.38 132.6,111.95 111.61,111.95 110.85,111.18 103.26,111.18 102.41,110.33 83.29,110.33 82.89,109.93 76.35,109.93 74.92,111.35 63.31,111.35 60.18,108.23 56.42,108.23 54.23,106.04 52.24,106.04 v1(51.45,105.25)
  BOTTOM w0.102: v1(51.45,105.25) 50.61,104.41 46.84,104.41 46.04,103.61 46.04,96.38 38.34,88.68 38.34,82.11 38.47,81.97 38.47,79.89 39.33,79.03 39.33,73.44 39.51,73.25 U9.57
  BOTTOM w0.203: R328.2 229.87,107.79 v1(229.94,107.86)
AU1_EN: length 5.6
  BOTTOM w0.203: U3.29 225.3,105.65 226.11,106.46 227.56,106.46 228.11,107.01 PC18.2 228.4,107.01 R328.1 228.4,107.79 PR17.1
AU1_SET1: length 7.2
  BOTTOM w0.203: U3.10 222.1,99.36 222.64,98.82 222.64,94.9 PR33.2 223.2,94.34 PR109.1
AU1_SET2: length 7.4
  BOTTOM w0.203: PR110.1 224.2,94.36 PR34.2 223.63,94.93 223.63,97.48 223.64,97.49 223.64,98.3 222.5,99.44 U3.9
AU1_SET3: length 7.7
  BOTTOM w0.203: U3.8 222.9,99.52 224.66,97.75 224.66,94.95 PR35.2 225.16,94.45 PR111.1
AU1_VR_RDY: length 6.1
  BOTTOM w0.203: U3.30 225.7,105.4 226.45,106.16 227.21,106.16 227.38,105.98 229.88,105.98 PR68.2 230.29,107.16 R340.1
AUXN_LVDS: length 8.3
  BOTTOM w0.109: U42.1 56.07,27.98 56.16,27.9 56.31,27.9 56.44,28.03 56.44,29.2 57.91,30.67 60.82,30.67 C187.1 61.22,31.84 R583.2
AUXP_LVDS: length 8.3
  BOTTOM w0.109: U42.2 56.03,27.58 56.13,27.68 56.16,27.68 56.4,27.68 56.66,27.94 56.66,29.11 58,30.45 61.02,30.45 C196.1 61.24,30.23 R581.1
BKUP_BAT: length 3.8
  BOTTOM w0.508: CN5.1 181.82,43.71 R222.2
BL_ADJ: length 30.1
  ART03 w0.102: v1(48.78,31.44) 48.39,31.05 44.03,31.05 43.12,31.96 43.12,35.49 36.92,41.7 28.12,41.7 v1(27.69,41.27)
  BOTTOM w0.102: v1(27.69,41.27) 28.22,41.8 R529.1 ; R586.1 v1(48.78,31.44)
BLCTL: length 20.7
  ART06 w0.102: v1(33.12,51.16) 33.12,53.68 37.05,57.61 37.06,57.6 38.58,57.6 38.59,57.59 39.92,57.59 v1(39.99,57.66)
  BOTTOM w0.102: v1(39.99,57.66) 40.18,57.85 R90.2 ; v1(33.12,51.16) 31.44,51.16 30.64,50.36 26.9,50.36 26.52,50.74 R545.2 27.04,51.3 27.34,51.6 U35.1
BRD_ID1: length 2.9
  TOP w0.102: v1(44.87,78.69) 45.05,78.51 R372.1 R360.2
  BOTTOM w0.102: v1(44.87,78.69) 44.56,78.38 U9.72
BRD_ID2: length 4.3
  TOP w0.102: v1(46.07,75.6) 45.88,75.41 45.88,74.62 R359.2 46.7,74.58 R361.1
  BOTTOM w0.102: v1(46.07,75.6) 44.96,76.7 U9.73
CA_VREF_CA: length 83.2
  TOP w0.305: v1(229.48,34.63) 228.7,34.63 228.47,34.41 218.71,34.41 218.01,35.11 206.64,35.11 206.61,35.14 v1(206.61,35.14)
  ART06 w0.305: v1(229.48,34.63) 229.67,34.45 230.67,34.45 231.38,35.16 231.38,42.53 231.98,43.14 231.98,62.15 231.82,62.31 v1(231.82,67.83)
  BOTTOM w0.305: v1(206.61,35.14) 207.01,35.14 208.34,33.81 208.34,32.76 207.8,32.22 R128.2 ; R43.2 217.5,63.69 217.19,64.01 217.19,66.49 217.52,66.83 219.39,66.83 220.24,67.68 220.24,68.77 220.55,69.08 226.71,69.08 227.63,68.16 230.75,68.16 231.21,67.7 231.69,67.7 v1(231.82,67.83)
CA_VREF_CB: length 130.2
  TOP w0.305: 229.06,33.45 229.06,32.62 229.47,32.2 229.47,29.35 228.38,28.26 228.38,22.89 227.7,22.22 202.17,22.22 201.97,22.02 CN19.164 v1(201.97,19.43) ; 229.06,33.45 229.06,33.71 ; 229.06,33.45 228.81,33.7 ; 228.81,33.7 229.06,33.95 ; 228.81,33.7 229.05,33.7 229.06,33.71 ; 228.81,33.7 228.59,33.93 217.52,33.93 216.84,34.61 206.2,34.61 206.13,34.67 v1(206.13,34.67) ; 229.06,33.95 v1(229.06,34.09) ; 229.06,33.95 229.06,33.71
  ART06 w0.305: v1(229.06,34.09) 228.93,34.22 228.93,35.05 229.16,35.28 229.61,35.28 229.89,35.01 230.54,35.01 230.88,35.34 230.88,42.61 231.58,43.31 231.58,61.54 231.33,61.78 231.33,68.37 231.42,68.46 v1(231.42,68.48)
  BOTTOM w0.305: v1(206.13,34.67) 207.36,33.45 R167.2 ; C142.2 199.5,19.44 R42.1 199.87,20.28 201.05,21.46 C156.2 201.85,21.46 R193.2 201.85,19.55 v1(201.97,19.43) ; R45.2 216.47,65.19 216.74,65.46 216.74,67.06 217.65,67.98 219.1,67.98 219.82,68.69 219.82,69.32 220,69.5 226.87,69.5 227.68,68.69 231.21,68.69 v1(231.42,68.48)
CAM_ON: length 107.4
  ART06 w0.102: v1(119.83,48.41) 119.8,48.41 119.66,48.56 100.81,48.56 98.6,50.77 90.77,50.77 89.88,49.87 83.18,49.87 82.71,50.34 50.04,50.34 47.46,52.92 47.46,55.72 46.54,56.64 46.54,60.2 47.68,61.35 47.68,64.56 46.91,65.33 v1(45,65.33)
  BOTTOM w0.102: v1(45,65.33) 45,65.42 47.83,68.25 47.83,69.53 48.79,70.5 48.79,73.05 47.83,74.02 47.83,75.07 46.56,76.34 U9.77 ; U41.4 120.77,48.85 R584.1 119.84,48.4 v1(119.83,48.41) 119.77,48.36 R578.2
CFG_RCOMP: length 1.9
  TOP w0.076: U1.AD6 v1(206.19,83.68)
  BOTTOM w0.305: R41.1 207.26,84.14 206.65,84.14 v1(206.19,83.68)
CHAGER_IOUT: length 350.6
  ART06 w0.203: v1(41.88,76.5) 42,76.38 42,69.57 44.76,66.82 47.25,66.82 48.44,65.64 48.44,60.25 47.83,59.64 47.83,56.77 48.17,56.44 48.17,53.04 50.26,50.95 82.89,50.95 83.21,50.62 89.23,50.62 90.05,51.44 98.68,51.44 100.82,49.3 130.04,49.3 130.75,48.58 133.03,48.58 arc(134.03,48.5) 135.01,48.25 arc(135.32,48.14) 135.63,48.02 arc(136.12,47.81) 136.6,47.59 arc(136.95,47.42) 137.28,47.24 144.24,40.28 144.24,23.48 148.16,19.57 149.7,19.57 151.83,17.43 151.83,14.04 157.12,8.75 195.35,8.75 196.37,9.76 204.15,9.76 204.65,9.26 207,9.26 207.41,8.85 231.17,8.85 233.31,10.99 233.31,13.28 232.56,14.04 232.56,14.93 232.99,15.36 232.99,22.42 233.11,22.55 233.11,23.34 232.94,23.51 232.94,29.51 231.34,31.11 231.34,31.83 232.7,33.19 232.7,39 233.44,39.74 233.44,41.66 232.34,42.77 232.34,64.52 232.6,64.78 232.6,93.33 v1(232.68,93.4)
  BOTTOM w0.102: v1(232.68,93.4) 232.65,93.4 232.34,93.1 229.83,93.1 228.74,92.01 228.74,90.91 227.98,90.15 226.15,90.15 225.77,89.78 223.6,89.78 222.91,90.46 222.91,91.04 222.33,91.63 222.33,94.62 222.13,94.82 R304.1 ; v1(41.88,76.5) 42.16,76.79 U9.66
CL_CLK: length 83.5
  TOP w0.076: U1.DV19 168.83,77.02 168.66,76.85 arc(168.55,76.78) 168.43,76.75 168.06,76.75 v1(167.82,77)
  TOP w0.109: v1(125.9,97.02) 125.9,97.1 126.15,97.36 R464.2
  ART06 w0.087: v1(125.9,97.02) 125.77,97.14 125.77,97.3 125.33,97.74 125.33,102.07 126.65,103.38 127.08,103.38 127.82,104.11 128.42,104.11 128.75,104.44 128.75,105.62 128.99,105.86 131.19,105.86 133.13,103.92 138.18,103.92 138.75,104.49 142.52,104.49 143.32,103.7 145.07,103.7 146.24,102.53 146.24,100.34 148.13,98.45 151.78,98.45 152.08,98.15 152.08,95.41 154.13,93.36 154.13,91.42 152.62,89.91 152.62,86.64 154.13,85.13 154.13,82.42 153.78,82.07 153.78,76.87 154.72,75.92 155.78,75.92 155.87,75.84 155.87,75.6 155.95,75.52 156.13,75.52 156.21,75.6 156.21,75.84 156.3,75.92 156.47,75.92 156.56,75.84 156.56,75.6 156.65,75.52 156.82,75.52 156.91,75.6 156.91,75.84 156.99,75.92 158.67,75.92 160.11,77.36 161.53,77.36 163.25,75.64 166.46,75.64 167.21,76.39 167.34,76.39 167.49,76.24 167.61,76.24 167.74,76.36 167.74,76.48 167.58,76.64 167.58,76.76 v1(167.82,77)
CL_DATA: length 83.6
  TOP w0.076: U1.DW19 168.06,77.4 167.51,77.4 v1(167.28,77.17)
  TOP w0.109: R463.2 126.03,98.12 125.3,97.39 v1(125.3,96.71)
  ART06 w0.087: v1(125.3,96.71) 125.3,97.19 124.86,97.63 124.86,102.17 126.54,103.85 126.92,103.85 127.3,104.24 127.3,105.12 128.53,106.36 131.32,106.36 133.34,104.34 138.02,104.34 138.58,104.9 142.84,104.9 143.54,104.19 145.29,104.19 146.66,102.82 146.66,100.71 148.22,99.15 152.07,99.15 152.53,98.69 152.53,95.64 154.55,93.62 154.55,91.2 153.07,89.71 153.07,86.9 154.55,85.41 154.55,82.22 154.21,81.89 154.21,77.1 154.92,76.39 158.57,76.39 160.09,77.92 161.55,77.92 161.97,77.5 162.68,77.5 164.33,75.85 165.96,75.85 v1(167.28,77.17)
CL_RST_N: length 88.3
  TOP w0.076: U1.DT19 170.12,77.29 169.65,77.29 169.35,77.29 169.28,77.36 168.58,77.36 168.31,77.63 167.42,77.63 167.32,77.53 166.48,77.53 v1(166.11,77.16)
  TOP w0.102: v1(124.73,96.99) 124.79,97.04 124.79,97.59 125.8,98.6 R462.2
  ART06 w0.102: v1(166.11,77.16) 166.11,76.76 165.6,76.24 164.67,76.24 163.04,77.88 161.97,77.88 161.51,78.33 160.11,78.33 158.6,76.81 155.28,76.81 154.8,77.3 154.8,81.91 155,82.12 155,85.67 153.77,86.89 153.77,89.65 155.45,91.32 155.45,93.52 153.12,95.85 153.12,98.67 152.3,99.49 148.56,99.49 147.6,100.45 147.6,102.55 145.7,104.45 143.7,104.45 143.02,105.13 138.47,105.13 137.95,104.6 133.42,104.6 131.44,106.58 128.06,106.58 126.94,105.46 126.94,104.36 126.67,104.09 126.3,104.09 124.43,102.22 124.43,97.29 v1(124.73,96.99)
CLKIN_XTAL_LCP: length 116.2
  TOP w0.109: R440.1 128.38,91.68 125.7,91.68 v1(125.23,92.16)
  ART03 w0.075: 119.17,75.72 119.26,75.81 119.26,75.91
  ART03 w0.087: v1(48.28,72.45) 48.4,72.57 50.23,72.57 50.71,72.09 51.3,72.09 51.78,72.57 58.16,72.57 59.63,74.04 60.1,74.04 60.47,74.42 65.43,74.42 65.79,74.78 77.67,74.78 78.49,73.95 78.49,73.51 79.76,72.24 83.33,72.24 84.39,71.18 84.95,71.18 85.44,71.67 89.94,71.67 90.35,71.26 93.29,71.26 94.16,70.39 95.02,70.39 95.98,71.35 107.01,71.35 107.21,71.55 111.02,71.55 112.91,73.44 116.89,73.44 119.17,75.72 ; v1(125.23,92.16) 124.77,91.7 124.09,91.7 119.58,87.19 119.58,78.74 119.26,78.42 119.26,75.91
  BOTTOM w0.109: R207.2 43.11,60.08 43.6,60.57 44.45,60.57 44.96,61.08 U9.24 44.96,63.04 44.54,63.45 44.54,65.75 46.41,67.62 46.41,71.02 47.85,72.46 48.27,72.46 v1(48.28,72.45)
CNV_BRI_DT: length 60.8
  TOP w0.102: R166.1 128.66,99.38 R466.1 127.82,99.88 127.56,100.14 v1(127.56,100.18) ; R286.2 162.3,71.98 v1(162.22,71.89)
  ART06 w0.102: v1(162.22,71.89) 161.98,72.13 158.95,72.13 158.42,72.67 156.03,72.67 151.94,76.76 151.94,84.37 149.27,87.03 149.27,94.9 148.86,95.31 145.43,95.31 141.97,98.76 141.97,101.07 140.84,102.21 130.76,102.21 128.78,100.23 127.61,100.23 v1(127.56,100.18)
CNV_BRI_RSP: length 65.1
  TOP w0.102: v1(128.1,101.95) 128.13,101.92 128.56,101.92 R158.1
  ART06 w0.102: v1(128.1,101.95) 128.1,101.97 128.55,102.43 140.96,102.43 142.26,101.13 142.26,98.78 145.51,95.53 148.95,95.53 149.52,94.96 149.52,87.19 152.15,84.56 152.15,76.83 156.05,72.93 158.48,72.93 159.06,72.35 163.44,72.35 164.48,73.39 166.58,73.39 v1(167.25,72.72)
  BOTTOM w0.075: v1(167.25,72.72) 167.59,72.38 168.45,72.38 R173.2
CNV_RECOMP: length 1.8
  TOP w0.203: U1.DT45 170.07,64.33 v1(170.07,64.08)
  BOTTOM w0.305: v1(170.07,64.08) 170.07,64.9 R226.1
CNV_RGI_DT: length 61.8
  TOP w0.102: v1(126.74,100.32) 126.76,100.33 126.76,100.47 127.31,101.02 127.45,101.02 R181.1 128,101.02 R161.1 ; v1(160.92,73.02) 161,72.93 R284.2
  ART06 w0.102: v1(160.92,73.02) 160.81,72.91 160.08,72.91 159.55,73.44 156.12,73.44 152.58,76.98 152.58,84.8 150.03,87.35 150.03,95.06 149.14,95.94 145.8,95.94 142.79,98.96 142.79,101.21 141.15,102.84 128.13,102.84 127.18,101.89 127.18,101.2 126.76,100.77 126.76,100.33 v1(126.74,100.32)
CNV_RGI_RSP: length 64.8
  TOP w0.102: v1(161.61,73.17) 162.47,73.17 R287.2 ; v1(126.19,100.3) 126.19,100.18 126.5,99.86 127,99.86 127.15,100.01 127.15,100.47 127.41,100.73 128.1,100.73 R164.1
  ART06 w0.102: v1(126.19,100.3) 126.19,100.61 126.77,101.2 126.77,101.79 128.06,103.07 141.35,103.07 143.06,101.36 143.06,99.04 145.94,96.17 149.22,96.17 150.49,94.9 150.49,88.57 151,88.06 151,86.78 152.78,85 152.78,77.06 156.09,73.76 161.02,73.76 v1(161.61,73.17)
CNV_WR_0_DN: length 71.8
  TOP w0.076: v1(170.91,64.81) U1.DP44
  TOP w0.109: CN22.15 137.65,105.11 136.63,104.1 v1(136.63,100.45)
  ART06 w0.075: 161.97,66.05 161.99,66.05 162.15,65.9 165.08,65.9 165.87,66.69 167.42,66.69 167.76,66.35 168.36,66.35 169.47,65.24 170.97,65.24 171.09,65.11 171.09,65.06 171.13,65.03 v1(170.91,64.81)
  ART06 w0.087: 161.97,66.05 161.94,66.05 161.72,66.28 158.85,66.28 158.43,65.86 157.63,65.86 156.92,65.15 151.99,65.15 151.28,65.86 151.28,66.54 145.25,72.57 145.25,76.83 144.05,78.03 144.05,91.98 139.63,96.4 138.82,96.4 136.7,98.53 136.7,100.39 v1(136.63,100.45)
CNV_WR_0_DP: length 71.8
  TOP w0.076: U1.DN44 171.56,64.82 v1(171.56,64.82)
  TOP w0.109: CN22.17 139.85,104.61 139.57,104.9 137.74,104.9 136.85,104.01 136.85,100.83 v1(137.24,100.45)
  ART06 w0.075: v1(171.56,64.82) 171.24,65.13 171.24,65.18 171.03,65.39 169.53,65.39 168.42,66.5 167.83,66.5 167.49,66.84 165.81,66.84 165.02,66.05 162.21,66.05 161.97,66.29
  ART06 w0.087: v1(137.24,100.45) 136.88,100.1 136.88,98.61 138.9,96.59 139.7,96.59 144.23,92.06 144.23,78.11 145.43,76.9 145.43,72.64 151.46,66.62 151.46,65.94 152.07,65.33 156.84,65.33 157.55,66.04 158.35,66.04 158.77,66.46 161.79,66.46 161.97,66.29
CNV_WR_1_DN: length 87.7
  TOP w0.076: v1(174.16,65.73) 174.17,65.73 U1.DG42
  TOP w0.109: CN22.9 136.53,106.61 134.89,104.97 134.89,100.53 v1(134.81,100.45)
  ART06 w0.075: v1(174.16,65.73) 174.16,65.68 174.39,65.45 174.61,65.45 175,65.06 175,64.81 175.21,64.61 175.21,63.92 174.43,63.13 169.33,63.13 168.94,63.52 168.94,64.29 168.33,64.91 166.21,64.91 165.68,65.44 163.78,65.44 163.28,64.95 163.28,62.75 162.11,61.58 162.11,61.56 162.1,61.55
  ART06 w0.087: v1(134.81,100.45) 134.81,99.42 138.71,95.53 139.26,95.53 143.28,91.51 143.28,77.66 144.45,76.49 144.45,69.96 145.85,68.56 147.1,68.56 150.2,65.46 150.72,65.46 151.7,64.48 155.97,64.48 159.07,61.38 161.93,61.38 162.1,61.55
CNV_WR_1_DP: length 87.7
  TOP w0.076: v1(174.11,64.81) 174.11,65.21 174.18,65.29 174.38,65.29 U1.DG44
  TOP w0.109: CN22.11 139.92,106.11 139.64,106.4 136.62,106.4 135.11,104.88 135.11,100.76 v1(135.42,100.45)
  ART06 w0.075: v1(174.11,64.81) 174.02,64.9 174.02,65.21 174.11,65.3 174.55,65.3 174.85,65 174.85,64.75 175.06,64.55 175.06,63.98 174.36,63.28 169.39,63.28 169.09,63.58 169.09,64.36 168.39,65.06 166.28,65.06 165.74,65.6 163.72,65.6 163.13,65.01 163.13,62.82 162.01,61.69 161.98,61.69 161.97,61.68
  ART06 w0.087: v1(135.42,100.45) 135,100.03 135,99.5 138.78,95.72 139.34,95.72 143.47,91.59 143.47,77.74 144.63,76.57 144.63,70.04 145.93,68.74 147.18,68.74 150.28,65.64 150.8,65.64 151.78,64.66 156.04,64.66 159.14,61.56 161.86,61.56 161.97,61.68
CNV_WR_CLK_DN: length 68.5
  TOP w0.076: v1(172.86,64.81) U1.DK44
  TOP w0.109: v1(138.42,100.45) 138.42,102.82 139.15,103.55 139.67,103.55 139.73,103.61 CN22.21
  ART06 w0.075: v1(172.86,64.81) 173.11,65.06 173.11,65.12 173.02,65.21 171.46,65.21 169.87,66.8 168.26,66.8 167.89,67.18 165.34,67.18 164.52,66.36 163.1,66.36 162.51,66.95 162,66.95 161.99,66.93 161.97,66.93
  ART06 w0.087: 161.97,66.93 158.39,66.93 158.07,66.61 157.45,66.61 156.73,65.89 154.17,65.89 151.28,68.78 149.96,68.78 146.32,72.42 146.32,76.91 144.79,78.43 144.79,92.51 138.42,98.88 v1(138.42,100.45)
CNV_WR_CLK_DP: length 68.5
  TOP w0.076: v1(173.51,64.82) 173.51,64.82 U1.DJ44
  TOP w0.109: v1(139.02,100.45) 138.64,100.83 138.64,102.73 139.27,103.36 139.49,103.36 139.73,103.11 CN22.23
  ART06 w0.075: v1(173.51,64.82) 173.26,65.07 173.26,65.19 173.09,65.36 171.53,65.36 169.93,66.95 168.33,66.95 167.95,67.33 165.27,67.33 164.46,66.51 163.16,66.51 162.57,67.1 162,67.1 161.99,67.12 161.97,67.12
  ART06 w0.087: 161.97,67.12 158.32,67.12 158,66.8 157.38,66.8 156.65,66.07 154.25,66.07 151.35,68.97 150.03,68.97 146.5,72.5 146.5,76.99 144.98,78.51 144.98,92.58 138.6,98.95 138.6,100.03 v1(139.02,100.45)
CNV_WT_0_DN: length 68.1
  TOP w0.076: v1(167.35,64.05) 167.21,64.18 167.21,64.29 167.34,64.42 168.65,64.42 168.72,64.35 168.72,64.21 168.81,64.11 169,64.11 169.08,64.19 169.08,64.3 U1.DV45
  TOP w0.109: CN22.65 139.73,92.61 139.45,92.33 139.25,92.33 139.14,92.44 139.14,92.51 139.03,92.62 138.81,92.62 138.7,92.51 138.7,92.44 138.59,92.33 138.38,92.33 138.27,92.44 138.27,92.51 138.16,92.62 137.94,92.62 137.83,92.51 137.83,92.44 137.72,92.33 137.59,92.33 137.4,92.52 137.4,92.81 137.5,92.9 137.5,92.92 v1(137.68,93.1)
  ART06 w0.087: v1(167.35,64.05) 167.04,64.35 167.04,64.42 167.13,64.51 168.01,64.51 168.34,64.17 168.34,63.64 168.08,63.37 166.13,63.37 165.94,63.18 165.82,63.18 165.65,63.36 165.53,63.36 165.41,63.23 165.41,63.11 165.58,62.94 165.58,62.82 165.45,62.69 165.33,62.69 165.24,62.78 165.1,62.78 164.98,62.66 164.98,62.55 165.09,62.45 165.09,62.33 162.98,60.22 161.99,60.22 161.97,60.24 158.23,60.24 155.31,63.16 151.29,63.16 150.18,64.27 149.16,64.27 146.52,66.9 144.8,66.9 143,68.7 143,75.75 141.25,77.51 141.25,86.87 137.26,90.85 137.26,92.68 v1(137.68,93.1)
CNV_WT_0_DP: length 68.1
  TOP w0.076: U1.DU45 169.64,64.6 167.27,64.6 v1(166.71,64.05)
  TOP w0.109: v1(137.08,93.1) 137.08,92.91 137.18,92.81 137.18,92.43 137.5,92.11 CN22.67
  ART06 w0.087: v1(137.08,93.1) 137.08,90.77 141.06,86.79 141.06,77.43 142.82,75.68 142.82,68.62 144.72,66.72 146.45,66.72 149.08,64.09 150.1,64.09 151.21,62.98 155.23,62.98 158.15,60.06 163.05,60.06 166.2,63.21 168.15,63.21 168.51,63.57 168.51,64.24 168.08,64.67 167.06,64.67 166.88,64.49 166.88,64.21 v1(166.71,64.05)
CNV_WT_1_DN: length 62.8
  TOP w0.076: v1(164.67,63.99) 164.84,64.17 164.84,64.43 165.14,64.73 166.63,64.73 166.88,64.97 168.28,64.97 168.3,64.95 168.31,64.95 168.32,64.94 169.29,64.94 169.36,65.02 169.36,65.44 169.44,65.52 169.56,65.52 169.73,65.34 U1.DU44
  TOP w0.109: CN22.59 139.73,94.11 139.59,93.97 138.75,93.97 138.43,93.66 138.43,93.21 v1(138.33,93.1)
  ART06 w0.087: v1(164.67,63.99) 164.67,64.42 164.58,64.51 164.21,64.51 163.96,64.26 163.96,62.5 162.19,60.73 161.99,60.73 161.97,60.71 158.59,60.71 155.49,63.8 151.39,63.8 150.39,64.8 149.48,64.8 146.56,67.71 145.51,67.71 143.64,69.58 143.64,76.06 141.79,77.91 141.79,87.1 138.33,90.56 v1(138.33,93.1)
CNV_WT_1_DP: length 62.8
  TOP w0.076: v1(165.25,63.96) 165.2,63.96 165.02,64.14 165.02,64.4 165.2,64.58 166.69,64.58 166.92,64.8 168.21,64.8 168.24,64.76 169.41,64.76 169.59,64.94 169.95,64.94 170.23,65.22 U1.DT44
  TOP w0.109: v1(138.93,93.1) 138.65,93.38 138.65,93.56 138.84,93.75 139.59,93.75 139.73,93.61 CN22.61
  ART06 w0.087: v1(138.93,93.1) 138.51,92.68 138.51,90.64 141.97,87.18 141.97,77.99 143.82,76.14 143.82,69.66 145.58,67.9 146.64,67.9 149.55,64.98 150.47,64.98 151.46,63.99 155.57,63.99 158.66,60.89 162.12,60.89 163.8,62.57 163.8,64.33 164.15,64.68 164.65,64.68 164.86,64.46 164.86,64.4 v1(165.25,63.96)
CNV_WT_CLK_DN: length 73.9
  TOP w0.076: v1(172.21,65.73) U1.DL42
  TOP w0.109: v1(137.45,88.66) 137.45,90.62 137.94,91.11 CN22.71
  ART06 w0.075: v1(172.21,65.73) 172.4,65.92 172.4,66.08 172.4,66.2 172.87,66.67 174.06,66.67 175.32,65.4 175.32,64.99 175.53,64.79 175.53,63.71 174.31,62.49 168.45,62.49 167.75,61.78 167.25,61.78 166.9,61.43 166.45,61.43 165.5,60.48 164.47,60.48 163.4,59.41 162,59.41 161.99,59.4 161.97,59.4
  ART06 w0.087: 161.97,59.4 157.51,59.4 154.8,62.11 151.02,62.11 149.89,63.24 148.62,63.24 146.04,65.82 144.67,65.82 142.13,68.37 142.13,74.19 140.38,75.94 140.38,86.53 139.45,87.46 137.82,87.46 137.45,87.83 v1(137.45,88.66)
CNV_WT_CLK_DP: length 73.9
  TOP w0.076: U1.DK42 v1(172.86,65.73)
  TOP w0.109: v1(138.05,88.66) 137.67,89.04 137.67,90.53 138.03,90.9 138.24,90.9 138.35,90.79 138.35,90.4 138.45,90.3 138.67,90.3 138.78,90.42 138.78,90.79 138.89,90.9 139.45,90.9 139.73,90.61 CN22.73
  ART06 w0.075: 161.97,59.58 161.99,59.58 162,59.57 163.33,59.57 164.4,60.63 165.43,60.63 166.38,61.58 166.84,61.58 167.19,61.93 167.68,61.93 168.39,62.64 174.25,62.64 175.38,63.77 175.38,64.73 175.17,64.93 175.17,65.34 174,66.52 172.93,66.52 172.55,66.14 172.55,66.08 172.55,66.04 v1(172.86,65.73)
  ART06 w0.087: 161.97,59.58 157.59,59.58 154.87,62.3 151.1,62.3 149.97,63.43 148.7,63.43 146.12,66.01 144.75,66.01 142.31,68.45 142.31,74.26 140.56,76.01 140.56,86.61 139.53,87.64 137.9,87.64 137.63,87.91 137.63,88.24 v1(138.05,88.66)
CPU_EOPIO_RCOMP: length 3.4
  TOP w0.203: 216.59,79.52 216.59,79.38 U1.B14
  TOP w0.305: R842.1 218.23,80.82 217.4,79.99 217.06,79.99 216.59,79.52
CPU_POPIRCOMP: length 1.1
  TOP w0.254: U1.CJ41 v1(183.98,66.46)
  BOTTOM w0.075: R80.1 183.7,66.74 v1(183.98,66.46)
CPU_SVIDALRT#: length 22
  ART06 w0.102: v1(228.75,93.81) 228.75,92.58 227.17,91 226.2,91 221.9,86.69 219.8,86.69 219.44,86.33 214.48,86.33 v1(214.22,86.59)
  BOTTOM w0.102: R306.2 213.48,85.91 R307.2 213.84,85.91 214.22,86.29 v1(214.22,86.59) ; R242.2 228.43,95.01 228.75,94.69 v1(228.75,93.81)
CPU_SVIDCLK: length 22.9
  TOP w0.076: v1(216.03,87.43) 215.98,87.38 215.95,87.38 215.53,86.96 213.55,86.96 213.18,86.59 213.18,85.75 U1.H2
  ART06 w0.087: v1(226.77,93.95) 227.14,93.95 227.4,93.68 227.4,92.48 226.92,91.99 225.77,91.99 223.94,90.16 221.56,87.79 219.36,87.79 218.88,87.3 216.31,87.3 216.25,87.37 216.15,87.37 216.09,87.43 v1(216.03,87.43)
  BOTTOM w0.109: v1(226.77,93.95) 226.5,94.22 226.5,95.36 226.26,95.59 R65.2 226.03,96.42 R235.2
CPU_SVIDDAT: length 22.7
  TOP w0.076: v1(216.19,86.87) 216.05,86.74 214.95,86.74 214.36,86.14 214.06,86.14 213.81,85.89 213.81,85.15 U1.H3
  ART06 w0.087: v1(216.19,86.87) 216.27,86.79 219.23,86.79 219.61,87.18 221.63,87.18 225.94,91.48 227.12,91.48 228.08,92.44 v1(228.08,93.67)
  BOTTOM w0.102: R305.1 216.13,86.93 v1(216.19,86.87)
  BOTTOM w0.109: R239.2 227.43,94.98 R32.1 228.08,94.33 v1(228.08,93.67)
CSCL/MSCL: length 13.1
  ART03 w0.102: v1(50.19,14.1) 50.19,17.28 49.58,17.89 49.58,19.36 50.19,19.96 v1(50.19,20.8)
  BOTTOM w0.109: U42.25 50.93,21.69 50.19,20.95 v1(50.19,20.8) ; R605.2 48.39,12.88 U44.6 49.7,12.88 50.19,13.37 v1(50.19,14.1)
CSDA/MSDA: length 14.5
  ART03 w0.102: v1(50.79,14.12) 50.79,17.37 51.18,17.76 51.18,18.88 50.79,19.27 v1(50.79,20.92)
  BOTTOM w0.109: U42.24 51.33,21.64 50.79,21.09 v1(50.79,20.92) ; v1(50.79,14.12) 50.74,14.07 50.74,12.71 49.65,11.61 U44.5 48.39,11.61 R606.2
CSI_RCOMP: length 2
  TOP w0.076: U1.B4 216.76,84.26 216.96,84.06 v1(217.6,84.06)
  BOTTOM w0.305: R224.2 217.96,83.7 v1(217.6,84.06)
DBG_PMODE: length 13.3
  TOP w0.075: U1.DL15 172.52,78.63 172.3,78.42 171.05,78.42 170.81,78.66 169.25,78.66 169.07,78.85 169.07,79.12 168.73,79.47 168.73,79.75 168.58,79.9 168.37,79.9 168.23,80.03 166.51,80.03 166.47,80.08 164.49,80.08 164.08,80.49 163.74,80.49 163.74,80.49 163.45,80.49 163.45,80.49 162.35,80.49 161.97,80.87
  TOP w0.102: R868.1 161.82,80.99 R867.2 161.97,80.87
DDR0_A_ALERT_N#: length 72.2
  TOP w0.076: v1(196.2,57.27) 196.19,57.28 196.18,57.28 195.84,57.62 195.84,61.01 195.24,61.61 195.24,62.03 195.4,62.19 195.4,62.38 195.4,62.38 195.4,62.48 195.39,62.52 195.35,62.57 195.35,62.84 195.42,62.97 195.48,63.1 195.48,63.7 U1.BD46
  TOP w0.135: CN11.116 187.97,29.03 187.61,28.66 v1(187.44,28.66)
  ART06 w0.108: v1(187.44,28.66) 187.37,28.59 187.37,24.77 188.68,23.46 195.08,23.46 197.03,25.41 197.03,29 199.54,31.51 200.95,31.51 201.69,32.26 201.77,32.26 209.03,39.52 209.03,43.76 206.9,45.89 203.12,45.89 199.28,49.74 199.28,50.51 198.14,51.64 198.14,56.69 197.71,57.12 196.35,57.12 v1(196.2,57.27)
DDR0_A_PARITY: length 83.3
  TOP w0.135: CN11.143 195.1,24.05 195.24,24.19 195.24,24.79 195.37,24.92 195.64,24.92 195.78,24.79 195.78,24.35 195.93,24.2 196.19,24.2 196.34,24.34 196.34,24.8 196.48,24.94 196.67,24.94 196.82,24.79 196.82,23.85 196.58,23.62 v1(196.44,23.62) ; v1(195.23,67.1) 194.97,67.36 U1.BF39
  ART06 w0.108: v1(195.23,67.1) 194.86,66.73 194.86,65.04 195.15,64.76 195.15,62.26 194.34,61.46 194.34,60.37 194.45,60.27 194.81,60.27 194.92,60.16 194.92,59.94 194.81,59.83 194.45,59.83 194.34,59.73 194.34,59 192.8,57.46 192.8,51.1 193.3,50.61 193.3,42.21 188.7,37.62 188.7,36.45 190.44,34.71 191.8,34.71 191.98,34.54 191.98,33.56 191.85,33.44 190.22,33.44 190.11,33.55 190.11,33.76 190.22,33.87 191.51,33.87 191.62,33.98 191.62,34.18 191.51,34.28 189.03,34.28 188.92,34.39 188.92,35.26 188.81,35.37 188.47,35.37 188.29,35.19 188.29,33.85 188.39,33.74 189.04,33.74 189.15,33.63 189.15,32.04 189.04,31.93 188.83,31.93 188.72,32.04 188.72,33.2 188.61,33.31 188.39,33.31 188.29,33.2 188.29,31.93 189.2,31.02 189.2,30.61 188.81,30.22 188.49,30.22 187.9,30.81 187.36,30.81 186.75,30.19 186.75,24.49 188.89,22.35 191.34,22.35 191.93,22.95 195.45,22.95 196.12,23.62 v1(196.44,23.62)
DDR1_B_ALERT_N: length 90.3
  TOP w0.076: v1(219.01,54.92) 218.22,55.71 218.22,57.91 217.76,58.37 213.88,58.37 213.86,58.38 213.08,59.17 213.08,59.17 211.61,60.64 211.61,62.11 211.48,62.24 U1.M49
  TOP w0.135: CN19.116 187.97,19.29 187.83,19.14 187.83,17.61 v1(188.44,17)
  ART03 w0.108: v1(188.44,17) 188.44,16.3 187.39,15.24 187.39,11.57 188.72,10.25 201.37,10.25 202.69,11.57 202.69,20.1 207.77,25.18 207.77,31.89 219.49,43.61 219.49,54.43 v1(219.01,54.92)
  BOTTOM w0.203: R44.1 218.77,54.68 v1(219.01,54.92)
DDR1_B_PARITY: length 93.6
  TOP w0.135: v1(194.24,14.61) 195.41,14.61 196.09,13.94 196.09,13.43 195.95,13.3 195.37,13.3 195.24,13.16 195.24,12.89 195.37,12.76 195.95,12.76 196.09,12.62 196.09,12.35 195.95,12.22 195.37,12.22 195.24,12.08 195.24,11.81 195.37,11.68 195.95,11.68 196.09,11.55 196.09,11.28 195.95,11.14 195.37,11.14 195.24,11.01 195.24,10.74 195.37,10.6 195.95,10.6 196.09,10.47 196.09,8.54 195.75,8.2 194.9,8.2 194.72,8.38 194.72,9.34 194.86,9.48 195.39,9.48 195.52,9.61 195.52,9.88 195.39,10.02 194.86,10.02 194.72,10.15 CN19.143 ; U1.P38 210.57,67.85 v1(210.76,67.73)
  ART03 w0.108: v1(210.76,67.73) 211.19,67.73 211.31,67.61 211.31,65.41 211.21,65.31 211.21,63.44 211.95,62.7 211.95,56.51 212.92,55.54 212.92,52.24 212.55,51.87 212.55,46.39 205.19,39.02 199.43,39.02 195.94,35.54 195.94,26.32 194.36,24.73 194.2,24.73 194.05,24.88 194.05,25.04 195.44,26.43 195.44,26.58 195.29,26.73 195.13,26.73 193.35,24.95 193.35,24.56 194.15,23.76 194.15,23.25 194.04,23.15 193.61,23.15 193.5,23.04 193.5,22.82 193.61,22.71 194.04,22.71 194.15,22.61 194.15,21.23 194.6,20.77 194.6,19.83 194.05,19.28 194.05,14.8 v1(194.24,14.61)
  BOTTOM w0.305: v1(210.76,67.73) 210.61,67.73 209.81,68.53 R74.1
DDR3VR_PWRGD: length 98.2
  ART06 w0.152: v1(111.92,61.07) 110.24,62.74 106.44,62.74 105.75,63.44 92.73,63.44 89.86,60.57 82.94,60.57 80.95,62.56 78.56,62.56 77.64,63.48 73.97,63.48 73.77,63.67 64.94,63.67 63.81,62.54 62.16,62.54 61.93,62.77 61.93,63.72 61.6,64.05 61.6,66 59.81,67.79 58.68,67.79 56.36,70.11 56.36,73.5 55.65,74.21 51.44,74.21 50.47,73.24 47.51,73.24 v1(47.34,73.07)
  BOTTOM w0.127: U2.10 112.47,55 R70.1 110.79,56.68 110.79,59.06 111.92,60.19 v1(111.92,61.07)
  BOTTOM w0.152: v1(47.34,73.07) 45.84,71.57 45.84,69.45 43.56,67.18 43.56,64.7 41.76,62.9 U9.32
DDR4_DRAMRST_R#: length 105.3
  TOP w0.076: v1(169.73,58.97) 169.9,59.14 170.93,59.14 172.76,60.97 172.76,60.98 172.78,61 172.78,61.81 173.04,62.07 173.04,62.52 173.01,62.61 173.01,62.82 173.06,62.9 173.07,62.92 173.08,62.95 U1.DK47
  TOP w0.102: v1(156.19,32.12) 157.15,31.17 157.15,23.24 158.17,22.21 169.5,22.21 169.79,22.5 175.38,22.5 175.66,22.21 v1(179.4,22.21)
  ART03 w0.102: v1(169.73,58.97) 169.79,58.92 169.79,58.1 169.36,57.68 168.52,57.68 166.76,55.92 166.76,54.14 164.93,52.31 162.5,52.31 161.54,51.34 161.54,50.73 158.41,47.61 158.41,45.48 157.34,44.41 156.16,44.41 154.96,43.21 154.96,33.35 v1(156.19,32.12)
  BOTTOM w0.102: R301.1 180.72,23.53 v1(179.4,22.21) ; R749.1 182.53,34.31 180.65,32.42 156.48,32.42 156.19,32.14 v1(156.19,32.12)
DDR_CA_VREF: length 6.8
  TOP w0.076: U1.C44 216.25,64.91 216.42,65.08 217.26,65.08 218.52,65.08 218.87,64.74 218.87,64.14 219.32,63.68 219.8,63.68 v1(219.89,63.77)
  BOTTOM w0.305: v1(219.89,63.77) 219.81,63.69 R43.1 218.7,63.68 C48.2
DDR_COMP_0: length 4.8
  TOP w0.076: U1.D47 215.94,63.38 216.19,63.13 216.19,62.83 216.32,62.71 216.83,62.71 217.07,62.47 217.3,62.47 217.72,62.05
  TOP w0.203: 217.72,62.05 217.95,61.81 219.21,61.81 R75.2
DDR_COMP_1: length 6.2
  TOP w0.075: U1.E46 215.02,63.85 215.02,63.19
  TOP w0.076: 216.5,61.97 216.41,62.06 215.95,62.06 215.7,62.31 215.7,62.51 215.02,63.19
  TOP w0.203: 216.5,61.97 217.04,61.43 218.83,61.43 R76.2
DDR_COMP_2: length 3.8
  TOP w0.076: 218.02,63.18 217.05,63.18 216.91,63.33 216.33,63.33 U1.C47
  TOP w0.203: R77.2 218.97,62.57 218.35,63.18 218.02,63.18
DDR_PG_CTRL: length 127.9
  TOP w0.135: v1(211.68,67.1) 211.5,67.2 U1.M39
  ART06 w0.102: v1(211.68,67.1) 211.2,67.58 211.2,67.99 211.08,68.12 210.09,68.12 209.97,68.23 186.85,68.23 186.35,68.73 184.92,68.73 184.62,68.44 184.62,66.93 184.4,66.71 184.4,66.24 182.84,64.68 181.8,64.68 181.53,64.41 181.53,64.08 172.54,55.08 172.54,53.71 167.1,48.28 153.89,48.28 153.68,48.07 149.76,48.07 149.15,48.68 147.76,48.68 142.63,53.8 139.03,53.8 133.31,59.52 124.96,59.52 123.42,61.06 119.1,61.06 117.62,59.57 115.03,59.57 115.03,59.56 114.63,59.56 114.62,59.57 113,59.57 112.58,59.15 108.39,59.15 v1(107.9,59.64)
  BOTTOM w0.102: v1(107.9,59.64) 107.9,59.92 107.41,60.41 106.4,60.41 105.36,59.37 105.36,58.2 105.51,58.04 U50.2
DDR_VTT_PG_CTRL: length 8.6
  BOTTOM w0.127: R118.2 R120.2 109.57,53.51 108.71,54.38 108.71,56.59 109.33,57.22 R752.2
  BOTTOM w0.152: U50.4 R752.2
DEVICE_PROCHOT#: length 387.9
  TOP w0.102: v1(39.14,62.85) 38.97,62.67 38.97,62.19 C342.1 U34.4
  ART03 w0.102: v1(229.91,93.63) 233.01,96.73 233.01,108.29 229.16,112.15 223.87,112.15 223.37,111.65 220.79,111.65 217.68,108.54 197.19,108.54 194.83,110.91 184.47,110.91 183.82,111.56 182.03,111.56 181.41,110.95 177.96,110.95 176.1,112.81 139.3,112.81 137.38,110.9 134.29,110.9 132.83,112.36 111.4,112.36 110.65,111.61 101.93,111.61 101.21,110.88 88.11,110.88 87.17,111.82 83.98,111.82 82.56,110.41 76.66,110.41 75.25,111.82 61.31,111.82 59.79,110.3 48.97,110.3 46.5,107.82 46.5,97.02 42.92,93.45 42.92,82.97 42.32,82.37 41.39,82.37 39.3,80.27 v1(39.3,79.85)
  ART06 w0.102: v1(219.98,86.26) 220.12,86.4 222.04,86.4 225.89,90.24 228.21,90.24 229.22,91.26 229.22,92.93 v1(229.91,93.63) 232.35,91.19 232.35,70.38 231.02,69.04 231.02,67.22 230.79,66.99 229.46,66.99 227.34,69.11 223.31,69.11 223.09,69.34 210.61,69.34 209.74,68.46 186.89,68.46 186.43,68.92 184.83,68.92 184.64,68.73 184.64,68.73 184.37,68.46 184.37,67.37 184.02,67.03 183.49,67.03 182.86,66.4 181.86,66.4 181.23,67.03 179.91,67.03 179.56,66.68 179.12,66.68 178.92,66.88 178.23,66.88 178.04,66.69 178.04,65.26 178.19,65.1 178.19,64.19 175.81,61.8 175.81,60.71 174.87,59.77 173.12,59.77 170.58,57.22 169.72,57.22 167.65,55.15 v1(166.39,55.15) ; v1(39.14,62.85) 40.92,64.62 40.92,69.65 41.72,70.45 41.72,75.94 39.62,78.04 39.62,79.52 v1(39.3,79.85)
  BOTTOM w0.075: v1(219.98,86.26) 219.56,86.67 R151.1 219.37,86.66 R122.2
  BOTTOM w0.102: v1(166.39,55.15) 166.72,54.81 D67.P ; v1(229.91,93.63) 229.91,94.89 229.56,95.24 R259.2
